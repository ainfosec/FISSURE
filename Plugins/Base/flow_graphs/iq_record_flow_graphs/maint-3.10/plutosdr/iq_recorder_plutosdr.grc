options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: iq_recorder_plutosdr
    output_language: python
    run_options: run
  states: {}

blocks:
- name: file_length
  id: variable
  parameters:
    value: '100000'
  states: {state: disabled}
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.2.1"'
  states: {state: disabled}
- name: lpf_cutoff
  id: variable
  parameters:
    value: '200000'
  states: {state: disabled}
- name: lpf_transition_width
  id: variable
  parameters:
    value: '50000'
  states: {state: disabled}
- name: rx_antenna
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: rx_channel
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: '2412'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '64'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.5'
    gate: 'True'
    ramp: '100'
    threshold: squelch_threshold
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(file_length)
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '200000'
    type: complex
  states: {}
- name: file_length
  id: parameter
  parameters:
    type: str
    value: '"100000"'
  states: {}
- name: filepath
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(float(rx_frequency)*1e6)
    gain1: '''manual'''
    manual_gain1: float(rx_gain)
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(float(sample_rate)*1e6)
    type: fc32
    uri: '"ip:" + str(ip_address)'
  states: {}
- name: ip_address
  id: parameter
  parameters:
    type: str
    value: '"192.168.2.1"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: lpf_transition_width
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: rx_antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    type: str
    value: '"2412"'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: str
    value: '"64"'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: str
    value: '"1"'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', low_pass_filter_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [iio_pluto_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_skiphead_0, '0']
- [low_pass_filter_0, '0', blocks_head_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
