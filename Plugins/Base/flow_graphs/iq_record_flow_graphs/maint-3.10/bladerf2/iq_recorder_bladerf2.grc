options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: iq_recorder_bladerf2
    output_language: python
    run_options: run
  states: {}

blocks:
- name: file_length
  id: variable
  parameters:
    value: '100000'
  states: {state: disabled}
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: lpf_cutoff
  id: variable
  parameters:
    value: '200000'
  states: {state: disabled}
- name: lpf_transition_width
  id: variable
  parameters:
    value: '50000'
  states: {state: disabled}
- name: rx_antenna
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: rx_channel
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: '2412'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '50'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: serial
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(file_length)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '200000'
    type: complex
  states: {}
- name: file_length
  id: parameter
  parameters:
    type: str
    value: '"100000"'
  states: {}
- name: filepath
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: file_length
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: '"bladerf=" + str(serial)'
    bb_gain0: '20'
    freq0: rx_frequency*1e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: rx_gain
    sample_rate: float(sample_rate)*1e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: rx_frequency
  id: parameter
  parameters:
    type: str
    value: '"2412"'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: str
    value: '"50"'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: str
    value: '"1"'
  states: {}
- name: serial
  id: parameter
  parameters:
    type: str
    value: '"0"'
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: float(rx_frequency)*1e6
    dev_args: '"bladerf=" + str(serial)'
    gain: float(rx_gain)
    samp_rate: float(sample_rate)*1e6
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [rtlsdr_source_0_0, '0', blocks_skiphead_0, '0']
- [soapy_bladerf_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
