options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: iq_recorder_limesdr
    output_language: python
    run_options: run
  states: {}

blocks:
- name: file_length
  id: variable
  parameters:
    value: '100000'
  states: {state: disabled}
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {state: disabled}
- name: lpf_cutoff
  id: variable
  parameters:
    value: '200000'
  states: {state: disabled}
- name: lpf_transition_width
  id: variable
  parameters:
    value: '50000'
  states: {state: disabled}
- name: rx_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {state: disabled}
- name: rx_channel
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: '2412'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.5'
    gate: 'True'
    ramp: '100'
    threshold: squelch_threshold
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(file_length)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '200000'
    type: complex
  states: {}
- name: file_length
  id: parameter
  parameters:
    type: str
    value: '"100000"'
  states: {}
- name: filepath
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: ip_address
  id: parameter
  parameters:
    type: str
    value: '"192.168.40.2"'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(rx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(rx_gain)
    gain_dB_ch1: int(rx_gain)
    oversample: '0'
    rf_freq: float(rx_frequency)*1e6
    samp_rate: float(sample_rate)*1e6
    serial: serial
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: lpf_transition_width
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: file_length
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: rx_antenna
  id: parameter
  parameters:
    type: str
    value: '"TX/RX"'
  states: {}
- name: rx_channel
  id: parameter
  parameters:
    type: str
    value: '"0"'
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    type: str
    value: '"2412"'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: str
    value: '"20"'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: str
    value: '"1"'
  states: {}
- name: serial
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', low_pass_filter_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [limesdr_source_0, '0', blocks_skiphead_0, '0']
- [low_pass_filter_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
