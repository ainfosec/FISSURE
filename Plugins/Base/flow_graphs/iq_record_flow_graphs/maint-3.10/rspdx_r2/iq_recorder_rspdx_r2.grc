options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: iq_recorder_rspdx_r2
    output_language: python
    run_options: run
  states: {}

blocks:
- name: file_length
  id: variable
  parameters:
    value: '100000'
  states: {state: disabled}
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: lpf_cutoff
  id: variable
  parameters:
    value: '200000'
  states: {state: disabled}
- name: lpf_transition_width
  id: variable
  parameters:
    value: '50000'
  states: {state: disabled}
- name: rx_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {state: disabled}
- name: rx_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: '102.5'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: '2.0'
  states: {state: disabled}
- name: serial
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(file_length)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '200000'
    type: complex
  states: {}
- name: file_length
  id: parameter
  parameters:
    type: str
    value: '"100000"'
  states: {}
- name: filepath
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: file_length
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: rx_antenna
  id: parameter
  parameters:
    type: str
    value: '"TX/RX"'
  states: {}
- name: rx_channel
  id: parameter
  parameters:
    type: str
    value: '"A:0"'
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    type: str
    value: '"102.5"'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: str
    value: '"25"'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: str
    value: '"2"'
  states: {}
- name: sdrplay3_rspdxr2_0
  id: sdrplay3_rspdxr2
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Antenna A
    bandwidth: '0'
    biasT: 'False'
    center_freq: float(rx_frequency)*1e6
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'False'
    if_gRdB: 59-float(rx_gain)
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_notch_filter: 'False'
    rsp_selector: str(serial)
    sample_rate: float(sample_rate)*1e6
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    synchronous_updates: 'False'
  states: {}
- name: serial
  id: parameter
  parameters:
    type: str
    value: '"False"'
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [sdrplay3_rspdxr2_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
