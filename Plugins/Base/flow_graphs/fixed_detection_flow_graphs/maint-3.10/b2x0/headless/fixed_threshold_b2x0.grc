options:
  parameters:
    author: user
    generate_options: no_gui
    id: fixed_threshold_b2x0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: below_zero
  id: variable
  parameters:
    value: '-1000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: full_band_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: in_box_spec_len
  id: variable
  parameters:
    value: int(np.abs(up_line_adj-low_line_adj))
  states: {}
- name: low_bound_vec_bottom_half
  id: variable
  parameters:
    value: (low_line_adj)*(below_zero,)
  states: {}
- name: low_bound_vec_top_half
  id: variable
  parameters:
    value: (fft_size-low_line_adj-1)*(below_zero,)
  states: {}
- name: low_line_adj
  id: variable
  parameters:
    value: '1'
  states: {}
- name: low_line_adj
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,4
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '8191'
    value: '1'
  states: {state: disabled}
- name: rx_antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: '        Antenna'
    labels: '["TX/RX", "RX2"]'
    num_opts: '0'
    options: '["TX/RX", "RX2"]'
    type: string
    value: antenna_default
  states: {state: disabled}
- name: rx_antenna
  id: variable
  parameters:
    value: antenna_default
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: ' Freq. (MHz):'
    orient: Qt.Horizontal
    start: '50'
    step: '.1'
    stop: '6000'
    value: float(rx_freq_default)
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: rx_freq_default
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: '              Gain:'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: float(gain_default)
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: float(gain_default)
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "2 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 2e6, 5e6, 10e6, 20e6]'
    type: real
    value: float(sample_rate_default)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: float(sample_rate_default)
  states: {}
- name: thresh_adj
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,4
    label: Thresh
    orient: Qt.Horizontal
    start: '-120'
    step: '1'
    stop: '20'
    value: float(threshold_default)
  states: {state: disabled}
- name: thresh_adj
  id: variable
  parameters:
    value: float(threshold_default)
  states: {}
- name: up_bound_vec_bottom_half
  id: variable
  parameters:
    value: (up_line_adj)*(below_zero,)
  states: {}
- name: up_bound_vec_top_half
  id: variable
  parameters:
    value: (fft_size-up_line_adj-1)*(below_zero,)
  states: {}
- name: up_line_adj
  id: variable
  parameters:
    value: '8191'
  states: {}
- name: up_line_adj
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,4
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '8191'
    value: '8191'
  states: {state: disabled}
- name: vec_height
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: ainfosec_msg_str_to_PUB_1
  id: ainfosec_msg_str_to_PUB
  parameters:
    address: '"tcp://127.0.0.1:5060"'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.2'
    freq: '-400000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: antenna_default
  id: parameter
  parameters:
    label: antenna_default
    type: str
    value: TX/RX
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: ((below_zero*10),)*(low_line_adj)+(0,)*in_box_spec_len+((below_zero*10),)*(fft_size-up_line_adj)
    type: float
    vlen: fft_size
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
    vlen: fft_size
    vlen_out: fft_size
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (thresh_adj,)*full_band_size
    vlen: fft_size
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: up_bound_vec_bottom_half+(vec_height,)+up_bound_vec_top_half
    vlen: fft_size
  states: {state: disabled}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: low_bound_vec_bottom_half+(vec_height,)+low_bound_vec_top_half
    vlen: fft_size
  states: {state: disabled}
- name: channel_default
  id: parameter
  parameters:
    label: channel_default
    type: str
    value: A:A
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time
      import pmt


      class blk(gr.sync_block):

          def __init__(
              self,
              vec_len=8192,
              sample_rate=1000000,
              rx_freq_mhz=2412,
              min_publish_interval_s=1.0,
          ):
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',
                  in_sig=[(np.float32, vec_len), (np.float32, vec_len)],
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern('detected_signals'))

              self.sample_rate = float(sample_rate)
              self.fft_size = int(vec_len)
              self.rx_freq_mhz = float(rx_freq_mhz)
              self.min_publish_interval_s = float(min_publish_interval_s)
              self.last_publish_time = 0.0

          def set_rx_freq_mhz(self, freq_mhz):
              self.rx_freq_mhz = float(freq_mhz)

          def set_min_publish_interval_s(self, value):
              self.min_publish_interval_s = float(value)

          def work(self, input_items, output_items):
              for vecindx in range(len(input_items[0])):
                  above_threshold = np.nonzero(
                      input_items[0][vecindx] > input_items[1][vecindx][0]
                  )[0]

                  if len(above_threshold) == 0:
                      continue

                  now = time.time()

                  if now - self.last_publish_time < self.min_publish_interval_s:
                      continue

                  self.last_publish_time = now

                  max_index = input_items[0][vecindx].argmax()

                  max_freq_hz = (
                      (max_index / float(self.fft_size)) * self.sample_rate
                      - (self.sample_rate / 2.0)
                      + (self.rx_freq_mhz * 1e6)
                  )

                  max_power = int(input_items[0][vecindx].max())

                  self.message_port_pub(
                      pmt.intern('detected_signals'),
                      pmt.intern(
                          f"TSI:/Signal Found/{max_freq_hz}/{max_power}/{now}"
                      )
                  )

              return len(input_items[0])
    min_publish_interval_s: float(min_interval)
    rx_freq_mhz: float(rx_freq)/1e6
    sample_rate: samp_rate
    vec_len: fft_size
  states: {}
- name: gain_default
  id: parameter
  parameters:
    label: gain_default
    type: str
    value: '65'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: ip_address
  id: parameter
  parameters:
    label: ip_address
    type: str
    value: ''
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: fft_size
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: min_interval
  id: parameter
  parameters:
    type: str
    value: '"1"'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '4'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: rx_freq_default
  id: parameter
  parameters:
    label: rx_freq_default
    type: str
    value: '2412000000'
  states: {}
- name: sample_rate_default
  id: parameter
  parameters:
    label: sample_rate_default
    type: str
    value: 20e6
  states: {}
- name: sensor_node_ip_address
  id: parameter
  parameters:
    label: sensor_node_ip_address
    type: str
    value: '"127.0.0.1"'
  states: {state: disabled}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: 'False'
  states: {}
- name: threshold_default
  id: parameter
  parameters:
    label: threshold_default
    type: str
    value: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_antenna
    center_freq0: float(rx_freq)
    dc_offs_enb0: '""'
    dev_addr: serial
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: channel_default
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_max_xx_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_add_xx_0, '0', logpwrfft_x_0, '0']
- [blocks_max_xx_0, '0', epy_block_0, '0']
- [blocks_max_xx_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_max_xx_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_0, '1']
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '3']
- [blocks_vector_source_x_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_vector_source_x_0_1, '0', qtgui_vector_sink_f_0, '2']
- [epy_block_0, detected_signals, ainfosec_msg_str_to_PUB_1, Message]
- [epy_block_0, detected_signals, blocks_message_debug_0, print]
- [logpwrfft_x_0, '0', blocks_add_const_vxx_0, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [uhd_usrp_source_0, '0', blocks_add_xx_0, '0']
- [uhd_usrp_source_0, '0', logpwrfft_x_0, '0']

metadata:
  file_format: 1
