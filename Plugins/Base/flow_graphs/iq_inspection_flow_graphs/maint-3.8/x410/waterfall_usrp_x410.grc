options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: waterfall_usrp_x410
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    orient: Qt.Horizontal
    start: '1'
    step: '.1'
    stop: '7200'
    value: '2412'
  states: {}
- name: rx_usrp_antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: '        Antenna'
    labels: '["TX/RX", "RX2"]'
    num_opts: '0'
    options: '["TX/RX", "RX2"]'
    type: string
    value: '"TX/RX"'
  states: {}
- name: rx_usrp_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s", "50 MS/s", "100 MS/s", "200 MS/s", "300 MS/s", "400 MS/s", "500 MS/s"]'
    num_opts: '0'
    options: '[1e6, 5e6, 10e6, 20e6, 50e6, 100e6, 200e6, 300e6, 400e6, 500e6]'
    type: real
    value: 1e6
  states: {}
- name: ip_address
  id: parameter
  parameters:
    label: ip_address
    type: str
    value: '"192.168.140.2"'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,6,4
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rx_usrp_channel
  id: parameter
  parameters:
    label: rx_usrp_channel
    type: str
    value: '"A:0"'
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_frequency*1e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: rx_usrp_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
