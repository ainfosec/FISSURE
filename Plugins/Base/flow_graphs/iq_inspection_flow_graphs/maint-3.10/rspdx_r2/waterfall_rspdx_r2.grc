options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: waterfall_rspdx_r2
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    start: '0.001'
    step: '.1'
    stop: '2000'
    value: '102.5'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    start: '0'
    step: '1'
    stop: '59'
    value: '0'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "2 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 2e6, 5e6, 10e6, 20e6]'
    type: real
    value: 2e6
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,6,4
    showports: 'True'
    type: complex
  states: {}
- name: sdrplay3_rspdxr2_0
  id: sdrplay3_rspdxr2
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Antenna A
    bandwidth: '0'
    biasT: 'False'
    center_freq: float(rx_frequency)*1e6
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'False'
    if_gRdB: 59-float(rx_gain)
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_notch_filter: 'False'
    rsp_selector: str(serial)
    sample_rate: float(sample_rate)
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    synchronous_updates: 'False'
  states: {}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: '0'
  states: {}

connections:
- [sdrplay3_rspdxr2_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
