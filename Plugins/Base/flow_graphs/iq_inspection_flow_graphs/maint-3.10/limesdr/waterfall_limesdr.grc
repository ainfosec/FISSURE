<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>waterfall_limesdr</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>value</key><value>2412</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>label</key><value> Freq. (MHz):</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>label</key><value>              Gain:</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>labels</key><value>["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1e6, 5e6, 10e6, 20e6]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>5e6</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>int(rx_gain)</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>50</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>rx_frequency*1e6</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,6,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
