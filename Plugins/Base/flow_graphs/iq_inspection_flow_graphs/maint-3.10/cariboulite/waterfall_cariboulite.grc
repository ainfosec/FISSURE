options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: waterfall_cariboulite
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    start: '70'
    step: '.1'
    stop: '6000'
    value: '2412'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    start: '-1'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 5e6, 10e6, 20e6]'
    type: real
    value: 1e6
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,6,4
    showports: 'True'
    type: complex
  states: {}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: '"0"'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: float(rx_frequency)*1e6
    gain0: float(rx_gain)
    samp_rate: float(sample_rate)
    type: fc32
  states: {}

connections:
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
