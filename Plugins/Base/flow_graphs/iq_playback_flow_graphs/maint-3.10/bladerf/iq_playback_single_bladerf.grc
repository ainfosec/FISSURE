options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: iq_playback_single_bladerf
    output_language: python
    run_options: run
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: ip_address
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: serial
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: tx_channel
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: tx_frequency
  id: variable
  parameters:
    value: '2425.715'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '30'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'False'
    type: complex
  states: {}
- name: filepath
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=" + str(serial)'
    bb_gain0: '20'
    freq0: float(tx_frequency)*1e6
    gain0: '10'
    if_gain0: float(tx_gain)
    sample_rate: float(sample_rate)*1e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: sample_rate
  id: parameter
  parameters:
    type: str
    value: '"4"'
  states: {}
- name: serial
  id: parameter
  parameters:
    type: str
    value: '"0"'
  states: {}
- name: tx_antenna
  id: parameter
  parameters:
    type: str
    value: '"TX/RX"'
  states: {}
- name: tx_frequency
  id: parameter
  parameters:
    type: str
    value: '"2425.715"'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: str
    value: '"30"'
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
