options:
  parameters:
    description: LFM matched-filter detector with independent in-band dBFS power measurement.
    generate_options: no_gui
    id: lfm_beacon_rtlsdr
    output_language: python
    run_options: run
    title: LFM Beacon RTL-SDR
  states: {}

blocks:
- name: rx_freq_default
  id: parameter
  parameters:
    label: rx_freq_default
    type: str
    value: 433e6
  states: {}
- name: gain_default
  id: parameter
  parameters:
    label: gain_default
    type: str
    value: '40.0'
  states: {}
- name: power_report_interval_default
  id: parameter
  parameters:
    label: power_report_interval_default
    type: str
    value: '0.25'
  states: {}
- name: ton
  id: variable
  parameters:
    value: '10e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: bw
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: Nmatch
  id: variable
  parameters:
    value: int(0.25 * ton * samp_rate)
  states: {}
- name: xlating_hz
  id: variable
  parameters:
    value: '-150e3'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '15'
  states: {}
- name: min_peak
  id: variable
  parameters:
    value: '20'
  states: {}
- name: holdoff_s
  id: variable
  parameters:
    value: '0.08'
  states: {}
- name: peak_window
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: eps
  id: variable
  parameters:
    value: '1e-12'
  states: {}
- name: avg_len
  id: variable
  parameters:
    value: int(0.01*samp_rate)
  states: {}
- name: lpf_cutoff
  id: variable
  parameters:
    value: bw*1.2
  states: {}
- name: lpf_trans
  id: variable
  parameters:
    value: bw/2
  states: {}
- name: matched_taps
  id: variable
  parameters:
    value: np.conjugate(np.exp(1j*2*np.pi*np.cumsum(((-bw/2)+(bw/ton)*(np.arange(Nmatch)/samp_rate)))/samp_rate)[::-1])
  states: {}
- name: power_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, lpf_cutoff, lpf_trans, window.WIN_HAMMING, 6.76)
  states: {}
- name: power_avg_len
  id: variable
  parameters:
    value: max(1, int(0.002*samp_rate))
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: float(rx_freq_default)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: float(gain_default)
  states: {}
- name: power_report_interval_s
  id: variable
  parameters:
    value: float(power_report_interval_default)
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"LFM beacon detector with separate received-power measurement."'
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_window
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rx_freq
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: freq_xlating_fir_filter_detect
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlating_hz
    decim: '1'
    samp_rate: samp_rate
    taps: matched_taps
    type: ccc
  states: {}
- name: blocks_complex_to_mag_squared_detect
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_detect_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '4000'
    scale: 1/avg_len
    type: float
  states: {}
- name: blocks_moving_average_detect_1
  id: blocks_moving_average_xx
  parameters:
    length: '64'
    max_iter: '4000'
    scale: 1/64
    type: float
  states: {}
- name: freq_xlating_fir_filter_power
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlating_hz
    decim: '1'
    samp_rate: samp_rate
    taps: power_taps
    type: ccc
  states: {}
- name: blocks_complex_to_mag_squared_power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_power
  id: blocks_moving_average_xx
  parameters:
    length: power_avg_len
    max_iter: '4000'
    scale: 1/power_avg_len
    type: float
  states: {}
- name: lfm_detector
  id: epy_block
  parameters:
    _source_code: |
      import time
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Detect LFM matched-filter peaks and report separate RF power."""

          def __init__(
              self,
              samp_rate=1e6,
              rx_freq_hz=433e6,
              thresh=15.0,
              min_peak=20.0,
              holdoff_s=0.08,
              peak_window=8000,
              eps=1e-12,
          ):
              gr.sync_block.__init__(
                  self,
                  name="lfm_beacon_detector",
                  in_sig=[np.float32, np.float32],
                  out_sig=None,
              )

              self.samp_rate = float(samp_rate)
              self.rx_freq_hz = float(rx_freq_hz)
              self.thresh = float(thresh)
              self.min_peak = float(min_peak)
              self.holdoff_s = float(holdoff_s)
              self.holdoff = int(self.holdoff_s * self.samp_rate)
              self.peak_window = int(peak_window)
              self.eps = float(eps)

              self.n = 0
              self.next_ok = 0
              self.in_peak = False
              self.peak_val = 0.0
              self.peak_power = self.eps
              self.peak_idx = 0
              self.peak_end = 0

              self.message_port_register_out(pmt.intern("det"))

          def set_samp_rate(self, samp_rate):
              self.samp_rate = float(samp_rate)
              self.holdoff = int(self.holdoff_s * self.samp_rate)

          def set_rx_freq_hz(self, rx_freq_hz):
              self.rx_freq_hz = float(rx_freq_hz)

          def set_thresh(self, thresh):
              self.thresh = float(thresh)

          def set_min_peak(self, min_peak):
              self.min_peak = float(min_peak)

          def set_holdoff_s(self, holdoff_s):
              self.holdoff_s = float(holdoff_s)
              self.holdoff = int(self.holdoff_s * self.samp_rate)

          def set_peak_window(self, peak_window):
              self.peak_window = int(peak_window)

          def work(self, input_items, output_items):
              metric = input_items[0]
              rf_power_linear = input_items[1]
              length = min(len(metric), len(rf_power_linear))

              for i in range(length):
                  idx = self.n + i
                  value = float(metric[i])
                  power = max(float(rf_power_linear[i]), self.eps)

                  if idx < self.next_ok:
                      continue

                  if not self.in_peak:
                      if value >= self.thresh:
                          self.in_peak = True
                          self.peak_val = value
                          self.peak_power = power
                          self.peak_idx = idx
                          self.peak_end = idx + self.peak_window
                      continue

                  if value > self.peak_val:
                      self.peak_val = value
                      self.peak_idx = idx

                  if power > self.peak_power:
                      self.peak_power = power

                  if idx >= self.peak_end:
                      if self.peak_val >= self.min_peak:
                          ts = time.time()
                          rf_power_dbfs = 10.0 * np.log10(max(self.peak_power, self.eps))
                          msg = (
                              f"TSI:/LFM Beacon/{self.rx_freq_hz:.1f}/"
                              f"{self.peak_val:.2f}/{ts:.6f}/{rf_power_dbfs:.2f}"
                          )
                          self.message_port_pub(pmt.intern("det"), pmt.intern(msg))

                      self.next_ok = self.peak_end + self.holdoff
                      self.in_peak = False
                      self.peak_val = 0.0
                      self.peak_power = self.eps

              self.n += length
              return length
    eps: eps
    holdoff_s: holdoff_s
    min_peak: min_peak
    peak_window: peak_window
    rx_freq_hz: rx_freq
    samp_rate: samp_rate
    thresh: threshold
  states: {}
- name: rf_power_reporter
  id: epy_block
  parameters:
    _source_code: |
      import time
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Print in-band RF power independently of LFM detection."""

          def __init__(
              self,
              samp_rate=1e6,
              rx_freq_hz=433e6,
              report_interval_s=0.25,
              eps=1e-12,
          ):
              gr.sync_block.__init__(
                  self,
                  name="rf_power_reporter",
                  in_sig=[np.float32],
                  out_sig=None,
              )

              self.samp_rate = float(samp_rate)
              self.rx_freq_hz = float(rx_freq_hz)
              self.report_interval_s = max(0.01, float(report_interval_s))
              self.eps = float(eps)

              self.report_samples = max(1, int(self.report_interval_s * self.samp_rate))
              self.sample_count = 0
              self.sum_power = 0.0
              self.peak_power = self.eps

          def set_samp_rate(self, samp_rate):
              self.samp_rate = float(samp_rate)
              self.report_samples = max(1, int(self.report_interval_s * self.samp_rate))
              self._reset_window()

          def set_rx_freq_hz(self, rx_freq_hz):
              self.rx_freq_hz = float(rx_freq_hz)

          def set_report_interval_s(self, report_interval_s):
              self.report_interval_s = max(0.01, float(report_interval_s))
              self.report_samples = max(1, int(self.report_interval_s * self.samp_rate))
              self._reset_window()

          def _reset_window(self):
              self.sample_count = 0
              self.sum_power = 0.0
              self.peak_power = self.eps

          def _publish_window(self):
              if self.sample_count <= 0:
                  return

              avg_power = max(self.sum_power / self.sample_count, self.eps)
              peak_power = max(self.peak_power, self.eps)
              avg_dbfs = 10.0 * np.log10(avg_power)
              peak_dbfs = 10.0 * np.log10(peak_power)
              ts = time.time()

              print(
                  f"POWER:/LFM Beacon/{self.rx_freq_hz:.1f}/"
                  f"{peak_dbfs:.2f}/{avg_dbfs:.2f}/{ts:.6f}",
                  flush=True,
              )
              self._reset_window()

          def work(self, input_items, output_items):
              power = np.asarray(input_items[0], dtype=np.float32)
              pos = 0
              length = len(power)

              while pos < length:
                  remaining = self.report_samples - self.sample_count
                  take = min(remaining, length - pos)
                  chunk = power[pos:pos + take]

                  if len(chunk):
                      self.sum_power += float(np.sum(chunk, dtype=np.float64))
                      self.peak_power = max(self.peak_power, float(np.max(chunk)))
                      self.sample_count += len(chunk)

                  pos += take

                  if self.sample_count >= self.report_samples:
                      self._publish_window()

              return length
    eps: eps
    report_interval_s: power_report_interval_s
    rx_freq_hz: rx_freq
    samp_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', freq_xlating_fir_filter_detect, '0']
- [freq_xlating_fir_filter_detect, '0', blocks_complex_to_mag_squared_detect, '0']
- [blocks_complex_to_mag_squared_detect, '0', blocks_moving_average_detect_0, '0']
- [blocks_moving_average_detect_0, '0', blocks_moving_average_detect_1, '0']
- [blocks_moving_average_detect_1, '0', lfm_detector, '0']
- [dc_blocker_xx_0, '0', freq_xlating_fir_filter_power, '0']
- [freq_xlating_fir_filter_power, '0', blocks_complex_to_mag_squared_power, '0']
- [blocks_complex_to_mag_squared_power, '0', blocks_moving_average_power, '0']
- [blocks_moving_average_power, '0', lfm_detector, '1']
- [blocks_moving_average_power, '0', rf_power_reporter, '0']
- [lfm_detector, det, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
