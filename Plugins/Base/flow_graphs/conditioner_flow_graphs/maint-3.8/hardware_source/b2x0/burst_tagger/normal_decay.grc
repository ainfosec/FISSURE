options:
  parameters:
    generate_options: no_gui
    id: normal_decay
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,1]'
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '1'
    value: '0.002'
  states: {state: disabled}
- name: antenna
  id: parameter
  parameters:
    label: antenna
    type: str
    value: TX/RX
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '5000'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: float(decay)
    type: float
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(float(sample_rate))
    type: complex
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: float(threshold)
    init: '0'
    low: float(threshold)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(sample_rate)
    type: complex
  states: {state: disabled}
- name: channel
  id: parameter
  parameters:
    label: channel
    type: str
    value: A:A
  states: {}
- name: decay
  id: parameter
  parameters:
    label: decay
    type: str
    value: '.0002'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Limit the number of burst events passing through.\n\n    Input:\n      float stream (gate signal: 0.0 or >0.0)\n\n    Output:\n      float stream, zeroed after max_bursts rising edges\n    \"\"\"\n\n    def __init__(self, max_bursts=5, gate_threshold=0.5):\n        gr.sync_block.__init__(\n            self,\n            name=\"limit_bursts\",\n            in_sig=[np.float32],\n            out_sig=[np.float32],\n        )\n\n        self.max_bursts = int(max_bursts)\n        self.gate_threshold = float(gate_threshold)\n\n        self._burst_count = 0\n        self._prev_gate = 0.0\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        y = output_items[0]\n\n        # Convert to boolean gate\n        gate = x > self.gate_threshold\n\n        # Build previous-sample array for rising edge detection\n        prev = np.empty_like(gate)\n        prev[0] = self._prev_gate\n        prev[1:] = gate[:-1]\n\n        # Rising edge = gate now high, previously low\n        rising_edges = gate & (~prev)\n        num_new = int(np.count_nonzero(rising_edges))\n\n        # Compute burst limit behavior\n        if self._burst_count >= self.max_bursts:\n            # Already exceeded limit → block everything\n            y[:] = 0.0\n        elif self._burst_count + num_new <= self.max_bursts:\n            # Safe: allow full block\n            y[:] = gate.astype(np.float32)\n        else:\n            # Crossing the boundary inside this block\n            remaining = self.max_bursts - self._burst_count\n            idxs = np.flatnonzero(rising_edges)\n\n            cutoff = idxs[remaining - 1]\n            y[:cutoff + 1] = gate[:cutoff + 1].astype(np.float32)\n            y[cutoff + 1:] = 0.0\n\n        self._burst_count += num_new\n        self._prev_gate = gate[-1]\n\n        return len(y)\n\n"
    gate_threshold: '0.5'
    max_bursts: int(max_bursts)
  states: {}
- name: filepath
  id: parameter
  parameters:
    label: filepath
    type: str
    value: '"/home/user/FISSURE/Conditioner Data/Input/one_each_1MSps.iq"'
  states: {state: disabled}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 50*[0.02]
    type: fff
  states: {state: disabled}
- name: gain
  id: parameter
  parameters:
    label: gain
    type: str
    value: '60'
  states: {}
- name: ip_address
  id: parameter
  parameters:
    label: ip_address
    type: str
    value: ''
  states: {}
- name: max_bursts
  id: parameter
  parameters:
    label: max_bursts
    type: str
    value: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(6371104/100)
    srate: float(sample_rate)
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"integrate"'
    size: int(6371104/100)
    srate: float(sample_rate)
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"threshold"'
    size: int(6371104/100)
    srate: float(sample_rate)
    type: float
  states: {state: disabled}
- name: rx_freq
  id: parameter
  parameters:
    label: rx_freq
    type: str
    value: '311'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: sample_rate
    type: str
    value: 1e6
  states: {}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: 'False'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: threshold
    type: str
    value: '.004'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    center_freq0: float(rx_freq)*1e6
    dc_offs_enb0: '""'
    dev_addr: serial
    dev_args: '""'
    gain0: float(gain)
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: float(sample_rate)
    sd_spec0: channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_burst_tagger_1, '0', blocks_keep_one_in_n_0, '0']
- [blocks_burst_tagger_1, '0', blocks_null_sink_0, '0']
- [blocks_burst_tagger_1, '0', blocks_tagged_file_sink_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_rms_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_rms_xx_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_threshold_ff_0_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_throttle_0, '0', blocks_delay_1, '0']
- [epy_block_0, '0', blocks_float_to_short_1, '0']
- [fir_filter_xxx_1_0, '0', blocks_rms_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_1, '0']

metadata:
  file_format: 1
