options:
  parameters:
    generate_options: no_gui
    id: normal_decay
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,1]'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '.001'
    stop: '1'
    value: '0.002'
  states: {state: disabled}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '20000'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/fissure-tsi/Conditioner/Data/Large_Test/one_each_1MSps_3_int16.iq
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: float(decay)
    type: float
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(float(sample_rate))
    type: short
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: float(threshold)
    init: '0'
    low: float(threshold)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(sample_rate)
    type: complex
  states: {}
- name: decay
  id: parameter
  parameters:
    label: decay
    type: str
    value: '.0002'
  states: {}
- name: filepath
  id: parameter
  parameters:
    label: filepath
    type: str
    value: '"/home/user/Conditioner/Data/tpms/four_tires2.iq"'
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 50*[0.02]
    type: fff
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(6209080/100/2)
    srate: float(sample_rate)
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"integrate"'
    size: int(6209080/100/2)
    srate: float(sample_rate)
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"threshold"'
    size: int(6209080/100/2)
    srate: float(sample_rate)
    type: float
  states: {state: disabled}
- name: sample_rate
  id: parameter
  parameters:
    label: sample_rate
    type: str
    value: 1e6
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: threshold
    type: str
    value: '5000'
  states: {}

connections:
- [blocks_burst_tagger_1, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_burst_tagger_1, '0', blocks_keep_one_in_n_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_rms_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_1, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_rms_xx_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_short_1, '0']
- [blocks_threshold_ff_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_throttle_0, '0', blocks_delay_1, '0']
- [fir_filter_xxx_1_0, '0', blocks_rms_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
