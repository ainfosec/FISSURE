options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: X10_OOK_USRPB210_Fields
    output_language: python
  states: {}

blocks:
- name: address_code
  id: variable
  parameters:
    value: '"0x60"'
  states: {}
- name: data_code
  id: variable
  parameters:
    value: '"0x00"'
  states: {}
- name: fuzzing_data
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: fuzzing_fields
  id: variable
  parameters:
    value: '"[''Address Code'']"'
  states: {state: disabled}
- name: fuzzing_interval
  id: variable
  parameters:
    value: '"5"'
  states: {state: disabled}
- name: fuzzing_max
  id: variable
  parameters:
    value: '"[''65535'']"'
  states: {state: disabled}
- name: fuzzing_min
  id: variable
  parameters:
    value: '"[''0'']"'
  states: {state: disabled}
- name: fuzzing_packet_type
  id: variable
  parameters:
    value: '"Default"'
  states: {state: disabled}
- name: fuzzing_protocol
  id: variable
  parameters:
    value: '"X10"'
  states: {state: disabled}
- name: fuzzing_seed
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: fuzzing_type
  id: variable
  parameters:
    value: '"[''Random'']"'
  states: {state: disabled}
- name: packet_types_fields
  id: variable
  parameters:
    value: '"{}"'
  states: {state: disabled}
- name: press_duration
  id: variable
  parameters:
    value: transmit_interval/2
  states: {state: disabled}
- name: press_repetition_interval
  id: variable
  parameters:
    value: transmit_interval
  states: {state: disabled}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '60'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {state: disabled}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {state: disabled}
- name: string_variables
  id: variable
  parameters:
    value: '["address_code","data_code"]'
  states: {state: disabled}
- name: transmit_interval
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: tx_frequency
  id: variable
  parameters:
    value: 310.8e6
  states: {state: disabled}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {state: disabled}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '60'
  states: {state: disabled}
- name: X10_msg_gen_fuzzer_0
  id: X10_msg_gen_fuzzer
  parameters:
    address_code: str(address_code)
    data_code: str(data_code)
    press_duration: float(transmit_interval)/2
    press_repetition_interval: float(transmit_interval)
    sample_rate: float(sample_rate)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: fuzzer_fuzzer_0_0
  id: fuzzer_fuzzer
  parameters:
    fuzzing_data: fuzzing_data
    fuzzing_fields: fuzzing_fields
    fuzzing_interval: fuzzing_interval
    fuzzing_max: fuzzing_max
    fuzzing_min: fuzzing_min
    fuzzing_packet_type: fuzzing_packet_type
    fuzzing_protocol: fuzzing_protocol
    fuzzing_seed: fuzzing_seed
    fuzzing_type: fuzzing_type
    packet_types_fields: packet_types_fields
  states: {}
- name: fuzzing_data
  id: parameter
  parameters:
    type: str
    value: '"0"'
  states: {}
- name: fuzzing_fields
  id: parameter
  parameters:
    type: str
    value: '"[''Address Code'']"'
  states: {}
- name: fuzzing_interval
  id: parameter
  parameters:
    type: str
    value: '"5"'
  states: {}
- name: fuzzing_max
  id: parameter
  parameters:
    type: str
    value: '"[''65535'']"'
  states: {}
- name: fuzzing_min
  id: parameter
  parameters:
    type: str
    value: '"[''0'']"'
  states: {}
- name: fuzzing_packet_type
  id: parameter
  parameters:
    type: str
    value: '"Default"'
  states: {}
- name: fuzzing_protocol
  id: parameter
  parameters:
    type: str
    value: '"X10"'
  states: {}
- name: fuzzing_seed
  id: parameter
  parameters:
    type: str
    value: '"0"'
  states: {}
- name: fuzzing_type
  id: parameter
  parameters:
    type: str
    value: '"[''Random'']"'
  states: {}
- name: packet_types_fields
  id: parameter
  parameters:
    type: str
    value: '"{}"'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: str
    value: '"1000000"'
  states: {}
- name: serial
  id: parameter
  parameters:
    type: str
    value: '"False"'
  states: {}
- name: transmit_interval
  id: parameter
  parameters:
    type: str
    value: '"4"'
  states: {}
- name: tx_frequency
  id: parameter
  parameters:
    type: str
    value: '"310.8e6"'
  states: {}
- name: tx_usrp_channel
  id: parameter
  parameters:
    type: str
    value: '"A:A"'
  states: {}
- name: tx_usrp_gain
  id: parameter
  parameters:
    type: str
    value: '"70"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: float(tx_frequency)
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: float(tx_usrp_gain)
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: float(sample_rate)
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [X10_msg_gen_fuzzer_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', X10_msg_gen_fuzzer_0, '0']
- [fuzzer_fuzzer_0_0, packet_out, X10_msg_gen_fuzzer_0, fuzzer_in]

metadata:
  file_format: 1
