options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: j2497_demod_method2
    output_language: python
  states: {}

blocks:
- name: chirp_section
  id: variable
  parameters:
    value: np.hstack((chirp(np.linspace(0E-6,33E-6,int(33E-6*samp_rate)),f0=203E3,f1=203E3,t1=33E-6,phi=-90,method='linear')*1))[::-1]
  states: {}
- name: chirp_section
  id: variable
  parameters:
    value: np.hstack((chirp(np.linspace(0E-6,33E-6,int(33E-6*samp_rate)),f0=100E3,f1=203E3,t1=33E-6,phi=-90,method='linear')*1))[::-1]
  states: {state: disabled}
- name: plot_samples
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: whole_chirp
  id: variable
  parameters:
    value: (np.hstack((chirp(np.linspace(0,63E-6,int(63E-6*samp_rate)),f0=203E3,f1=400E3,t1=63E-6,phi=0,method='linear')*1,chirp(np.linspace(63E-6,67E-6,int(4E-6*samp_rate)),f0=400E3,f1=100E3,t1=67E-6,phi=0,method='linear')*1,chirp(np.linspace(67E-6,100E-6,int(33E-6*samp_rate)),f0=100E3,f1=203E3,t1=100E-6,phi=-90,method='linear')*1)))[::-1]
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '5000'
    lo: '200'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 135-30
    type: complex
  states: {}
- name: blocks_file_source_0_1_0_1
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: chirp_section
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: whole_chirp
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 10*[0.1]
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 10*[0.1]
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-1e6'
    decim: '2'
    samp_rate: samp_rate*2
    taps: firdes.complex_band_pass(1, 2e6, 50e3, 450e3, 1e3)
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from scipy.signal import chirp
  states: {}
- name: j2497_j2497_decoder_for_tagger_0
  id: j2497_j2497_decoder_for_tagger
  parameters:
    do_udp: 'False'
    udp_port: '6972'
  states: {}
- name: j2497_j2497_tagger_0
  id: j2497_j2497_tagger
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: '"Correlation with Whole Chirp"'
    size: plot_samples
    srate: '1'
    type: float
    ymax: '900'
    ymin: '100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: '"Correlation Result"'
    size: plot_samples
    srate: '1'
    type: float
    ymax: '210'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: '"Tagged Signal"'
    size: plot_samples
    srate: '1'
    type: complex
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: 126e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate*2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 126e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate*2
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://111.111.111.111:55555"'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_rail_ff_0, '0', j2497_j2497_tagger_0, '1']
- [analog_rail_ff_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', fir_filter_xxx_1_0_0_0, '0']
- [blocks_delay_0, '0', j2497_j2497_tagger_0, '0']
- [blocks_file_source_0_1_0_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', fft_filter_xxx_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [fir_filter_xxx_1_0_0_0, '0', analog_rail_ff_0, '0']
- [fir_filter_xxx_1_0_0_0_0, '0', j2497_j2497_decoder_for_tagger_0, '0']
- [fir_filter_xxx_1_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [j2497_j2497_decoder_for_tagger_0, out, blocks_message_debug_0, print]
- [j2497_j2497_tagger_0, '0', fft_filter_xxx_0, '0']
- [j2497_j2497_tagger_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
