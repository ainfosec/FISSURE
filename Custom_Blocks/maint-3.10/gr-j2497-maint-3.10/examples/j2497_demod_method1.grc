options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: j2497_demod_method1
    output_language: python
  states: {}

blocks:
- name: chirp_section
  id: variable
  parameters:
    value: np.hstack((chirp(np.linspace(0E-6,33E-6,int(33E-6*samp_rate)),f0=100E3,f1=203E3,t1=33E-6,phi=-90,method='linear')*1))[::-1]
  states: {state: disabled}
- name: chirp_section
  id: variable
  parameters:
    value: np.hstack((chirp(np.linspace(0E-6,33E-6,int(33E-6*samp_rate)),f0=203E3,f1=203E3,t1=33E-6,phi=-90,method='linear')*1))[::-1]
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samples
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '20'
    type: float
  states: {}
- name: blocks_file_source_0_1_0_1
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '10'
    init: '0'
    low: '.1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: chirp_section
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 20*[0.05]
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-1e6'
    decim: '2'
    samp_rate: samp_rate*2
    taps: firdes.complex_band_pass(1, 2e6, 50e3, 450e3, 1e3)
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from scipy.signal import chirp
  states: {}
- name: j2497_J2497_decoder_corr_0
  id: j2497_J2497_decoder_corr
  parameters:
    do_udp: 'False'
    udp_port: '6972'
  states: {}
- name: qtgui_time_sink_x_0_0_0_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    label1: ''
    legend: 'False'
    name: '"Complex to Mag^2"'
    size: samples
    srate: '1'
    tr_delay: '15'
    tr_level: '0'
    tr_tag: ''
    type: float
    ymax: '400'
    ymin: '-10'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_3_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    legend: 'False'
    name: '"Correlation Result"'
    size: samples
    srate: '1'
    tr_delay: '15'
    tr_level: '0'
    tr_tag: ''
    type: float
    ymax: '400'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0_0_3_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    label1: ''
    legend: 'False'
    name: '"After Threshold"'
    size: samples
    srate: '1'
    tr_delay: '15'
    tr_level: '0'
    tr_tag: ''
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_3_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    label1: ''
    legend: 'False'
    name: '"After Moving-Average"'
    size: samples
    srate: '1'
    tr_delay: '15'
    tr_level: '0'
    tr_tag: ''
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: 126e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate*2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 126e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate*2
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://111.111.111.111:55555"'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_burst_tagger_1, '0', j2497_J2497_decoder_corr_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_0_0_0_3_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_delay_1, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_0_0_0_3, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_1, '0']
- [blocks_file_source_0_1_0_1, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_short_1, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0_0_0_3_0_0, '0']
- [blocks_throttle_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_threshold_ff_0_0, '0']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0_0_0_3_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [j2497_J2497_decoder_corr_0, out, blocks_message_debug_0, print]
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
