options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: j2497_demod_method3
    output_language: python
  states: {}

blocks:
- name: amp_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Amplitude Threshold
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.5'
  states: {}
- name: if_peak_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    label: IF Peak Offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '106'
  states: {}
- name: if_peak_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: IF Peak Threshold
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samples
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '5'
    type: complex
  states: {}
- name: blocks_file_source_0_1_0_1
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '50'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: amp_threshold
    init: '0'
    low: amp_threshold
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[.25, .25, .25, .25]'
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 10*[0.1]
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-1e6'
    decim: '2'
    samp_rate: samp_rate*2
    taps: firdes.complex_band_pass(1, 2e6, 50e3, 450e3, 1e3)
    type: ccc
  states: {state: disabled}
- name: j2497_J2497_decoder_0
  id: j2497_J2497_decoder
  parameters:
    do_udp: 'False'
    if_peak_offset: if_peak_offset
    if_peak_threshold: if_peak_threshold
    udp_port: '6972'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: '"out"'
    size: '200000'
    srate: '1'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,3,1
    label1: ''
    label2: ''
    name: '"Low Resolution"'
    size: '200000'
    srate: '1'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: '"Magnitude^2"'
    size: '20000'
    srate: '1'
    tr_level: amp_threshold
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '-.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: '"Instantaneous Frequency"'
    size: '100000'
    srate: '1'
    type: float
    ymax: '10'
    ymin: '0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: 126e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate*2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 126e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: 2e6
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://111.111.111.111:55555"'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_tag_gate_0, '0']
- [blocks_burst_tagger_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_1, '0']
- [blocks_delay_0, '0', blocks_burst_tagger_0, '0']
- [blocks_file_source_0_1_0_1, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_multiply_xx_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fir_filter_xxx_0_0, '0', j2497_J2497_decoder_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [fir_filter_xxx_1, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [j2497_J2497_decoder_0, out, blocks_message_debug_0, print]
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
