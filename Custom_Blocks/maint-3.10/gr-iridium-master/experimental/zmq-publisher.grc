options:
  parameters:
    generate_options: no_gui
    id: zmq_publisher
    output_language: python
    title: ZMQ Publisher
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '1622000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: freq
    center_freq1: freq
    dev_args: num_recv_frames=1024,recv_frame_size=8000
    gain0: '36'
    gain1: '36'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    dev_args: num_recv_frames=1024,recv_frame_size=8000
    gain0: '36'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:5001
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [soapy_plutosdr_source_0, '0', fosphor_qt_sink_c_0, '0']
- [soapy_plutosdr_source_0, '0', zeromq_pub_sink_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', zeromq_pub_sink_0, '0']
- [uhd_usrp_source_0, '1', zeromq_pub_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
