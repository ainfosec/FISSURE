options:
  parameters:
    generate_options: qt_gui
    id: fft_channelizer_demo
    output_language: python
    title: FFT Channelizer Demo
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.01'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: iridium_fft_channelizer_0_0
  id: iridium_fft_channelizer
  parameters:
    activate_streams: 'True'
    decimation: '2'
    drop_overflow: 'False'
    fft_size: '1024'
    max_burst_size: '100000'
    max_outstanding: '500'
    pdu_ports: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', iridium_fft_channelizer_0_0, '0']
- [iridium_fft_channelizer_0_0, '0', qtgui_freq_sink_x_0, '0']
- [iridium_fft_channelizer_0_0, '1', qtgui_freq_sink_x_0_1, '0']
- [iridium_fft_channelizer_0_0, '2', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
