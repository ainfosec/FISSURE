options:
  parameters:
    category: Custom
    description: IEEE 802.15.4 Transceiver using CSS PHY
    generate_options: qt_gui
    id: transceiver_CSS_USRP
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Transceiver using CSS PHY
  states: {}

blocks:
- name: c
  id: variable
  parameters:
    value: ieee802_15_4.css_phy(chirp_number=4, phy_packetsize_bytes=len(text_msg)+15)
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10'
    step: '1'
    stop: '1000'
    value: '300'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: text_msg
  id: variable
  parameters:
    value: '"Hello World, this is GNU Radio using the IEEE 802.15.4 CSS PHY!"'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(text_msg)
    period: interval
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: ieee802_15_4_css_phy_1
  id: ieee802_15_4_css_phy
  parameters:
    bits_per_cw: c.bits_per_symbol
    chirp_seq: c.chirp_seq
    codewords: c.codewords
    intlv_seq: c.intlv_seq
    len_sub: '38'
    nbytes_payload: c.phy_packetsize_bytes
    nsamp_frame: c.nsamp_frame
    num_subchirps: c.n_subchirps
    nzeros_padding: c.padded_zeros
    phr: c.PHR
    preamble: c.preamble
    sfd: c.SFD
    sym_per_frame: c.nsym_frame
    threshold: '0.95'
    time_gap_1: c.time_gap_1
    time_gap_2: c.time_gap_2
  states: {}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ieee802_15_4
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: note_samprate
  id: note
  parameters:
    note: Adjust sample rate as needed, standard compliant is 32e6 Hz
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: addr=192.168.10.6
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: addr=192.168.10.4
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee802_15_4_rime_stack_0, bcin]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_css_phy_1, '0', uhd_usrp_sink_1, '0']
- [ieee802_15_4_css_phy_1, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, foo_wireshark_connector_0, in]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_css_phy_1, txin]
- [ieee802_15_4_rime_stack_0, bcout, network_socket_pdu_0, pdus]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [uhd_usrp_source_0, '0', ieee802_15_4_css_phy_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
