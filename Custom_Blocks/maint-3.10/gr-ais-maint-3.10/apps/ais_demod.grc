options:
  parameters:
    author: Nick Foster
    category: '[AIS]'
    generate_options: hb
    id: ais_rx_core
    output_language: python
    title: AIS receiver core
  states: {}

blocks:
- name: bb_rate
  id: variable
  parameters:
    value: data_rate*bb_sps
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: marking_delay
  id: variable
  parameters:
    comment: Empirically found.
    value: '[5,2,6,2,9,4,5][round(bb_sps-2)]'
  states: {}
- name: modulated_preamble
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: digital.cpmmod_bc(analog.cpm.GAUSSIAN, 0.5, bb_sps, int(1/bt)+2,bt).to_basic_block()
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: preamble
  id: variable
  parameters:
    comment: |-
      CPM modulator takes 
      unsigned bipolar. Not 
      a great idea.
    value: '[1,1,255,255]*7'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/data_rate
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: math.pi/2
  states: {}
- name: bb_sps
  id: parameter
  parameters:
    label: Demod SPS
    type: intx
    value: '4'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      ~0 is -1. ~1 is -2.
      what a world.
    const: '2'
    type: byte
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: bt
  id: parameter
  parameters:
    label: Bandwidth-time product
    type: eng_float
    value: '0.4'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: marking_delay
    sps: bb_sps
    symbols: modulated_preamble
    threshold: threshold
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: loopbw
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: bb_sps
    ted_gain: '0.45'
    ted_type: digital.TED_DANDREA_AND_MENGALI_GEN_MSK
    type: cc
  states: {}
- name: loopbw
  id: parameter
  parameters:
    label: TED loop bw
    type: eng_float
    value: '0.05'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: corr_sig
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: ted_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: ted_error
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: corr
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_2
  id: pad_sink
  parameters:
    label: agc_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: (bb_sps*data_rate)/samp_rate
    taps: firdes.low_pass(nfilts, samp_rate*nfilts, data_rate*0.6, data_rate*0.1, window.WIN_HANN)
    type: ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 200e3
  states: {}
- name: square_and_fft_sync_0
  id: square_and_fft_sync
  parameters:
    bits_per_sec: data_rate
    comment: |-
      this is probably unnecessary.
      a good upgrade would be a
      block which derotates the
      packet upon detecting a
      corr_start tag downstream
      of the correlation estimator.
    fftlen: '1024'
    samp_rate: bb_rate
  states: {state: bypassed}
- name: threshold
  id: parameter
  parameters:
    label: Preamble correlator threshold
    type: eng_float
    value: '0.83'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ted_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ted_out
  states: {}

connections:
- [analog_agc3_xx_0, '0', digital_corr_est_cc_0, '0']
- [analog_agc3_xx_0, '0', pad_sink_0_2, '0']
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0, '0', digital_hdlc_deframer_bp_0, '0']
- [blocks_not_xx_0, '0', blocks_add_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_corr_est_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_corr_est_cc_0, '0', pad_sink_0, '0']
- [digital_corr_est_cc_0, '1', pad_sink_0_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_not_xx_0, '0']
- [digital_hdlc_deframer_bp_0, out, pad_sink_0_0_0_0, in]
- [digital_symbol_sync_xx_0, '0', pad_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0, '1', pad_sink_0_0_0, '0']
- [pad_source_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', square_and_fft_sync_0, '0']
- [square_and_fft_sync_0, '0', analog_agc3_xx_0, '0']
- [virtual_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
