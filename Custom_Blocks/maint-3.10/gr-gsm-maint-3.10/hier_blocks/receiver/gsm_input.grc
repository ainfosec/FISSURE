options:
  parameters:
    author: Piotr Krysik
    category: ''
    description: Adaptor of input stream for the GSM receiver. Contains frequency ofset corrector doing also resampling to integer multiplies of GSM sample rate and LP filter filtering GSM channel.
    generate_options: hb
    id: gsm_input
    output_language: python
    title: GSM input adaptor
  states: {}

blocks:
- name: gsm_symb_rate
  id: variable
  parameters:
    value: 1625000.0/6.0
  states: {}
- name: samp_rate_out
  id: variable
  parameters:
    value: gsm_symb_rate*osr
  states: {}
- name: ctrl_in
  id: pad_source
  parameters:
    label: ctrl_in
    optional: 'True'
    type: message
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    type: eng_float
    value: 940e6
  states: {}
- name: gsm_clock_offset_corrector_tagged_0
  id: gsm_clock_offset_corrector_tagged
  parameters:
    fc: fc
    osr: osr
    ppm: ppm
    samp_rate_in: samp_rate_in
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 125e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_out
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate_in/samp_rate_out
    type: complex
  states: {state: disabled}
- name: osr
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: ppm
    type: eng_float
    value: '0'
  states: {}
- name: samp_rate_in
  id: parameter
  parameters:
    label: samp_rate_in
    type: eng_float
    value: 1e6
  states: {}

connections:
- [ctrl_in, out, gsm_clock_offset_corrector_tagged_0, ctrl]
- [gsm_clock_offset_corrector_tagged_0, '0', low_pass_filter_0_0, '0']
- [gsm_clock_offset_corrector_tagged_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0_0, '0', pad_sink_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0_0, '0']
- [pad_source_0, '0', gsm_clock_offset_corrector_tagged_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
