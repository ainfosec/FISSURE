<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gsm_bcch_ccch_sdcch4_demapper</value></param>
<param><key>author</key><value>Piotr Krysik</value></param>
<param><key>category</key><value></value></param>
<param><key>description</key><value>Demapper for BCCH + CCCH + SDCCH/4 + SACCH/C4 control channels. This corresponds to channel combination v specified in GSM 05.02, section 6.4</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>BCCH + CCCH + SDCCH/4 demapper</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0</value></param>
<param><key>downlink_channel_types</key><value>[0,0,1,1,1,1,2,2,2,2,0,0,2,2,2,2,2,2,2,2,0,0,7,7,7,7,7,7,7,7,0,0,7,7,7,7,7,7,7,7,0,0,135,135,135,135,135,135,135,135,0]</value></param>
<param><key>downlink_starts_fn_mod51</key><value>[0,0,2,2,2,2,6,6,6,6,0,0,12,12,12,12,16,16,16,16,0,0,22,22,22,22,26,26,26,26,0,0,32,32,32,32,36,36,36,36,0,0,42,42,42,42,46,46,46,46,0]</value></param>
<param><key>downlink_subslots</key><value>[0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,2,2,2,2,0,0,0,0,0,0,1,1,1,1,0,0,2,2,2,2,3,3,3,3,0,0,0,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,2,2,2,2,0,0,0,0,0,0,1,1,1,1,0,0,2,2,2,2,3,3,3,3,0,0,2,2,2,2,3,3,3,3,0]</value></param>
<param><key>timeslot_nr</key><value>timeslot_nr</value></param>
<param><key>uplink_channel_types</key><value>[7,7,7,7,3,3,135,135,135,135,135,135,135,135,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,7,7,7,7,7,7,7,7,3,3,7,7,7,7]</value></param>
<param><key>uplink_starts_fn_mod51</key><value>[0,0,0,0,4,5,6,6,6,6,10,10,10,10,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,37,37,37,41,41,41,41,45,46,47,47,47,47,]</value></param>
<param><key>uplink_subslots</key><value>[3,3,3,3,0,0,2,2,2,2,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,0,0,2,2,2,2,3,3,3,3,0,0,0,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,0,0,2,2,2,2,]</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>bursts</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>bursts</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timeslot_nr</value></param>
<param><key>label</key><value>timeslot_nr</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>bursts</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0</sink_block_id><source_key>out</source_key><sink_key>bursts</sink_key></connection>
</flow_graph>
