options:
  parameters:
    author: schneider
    generate_options: qt_gui
    id: iridium_subscriber
    output_language: python
    run_options: run
    title: Iridium Subscriber
  states: {}

blocks:
- name: big_low_pass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/4 - publisher_transition + transition/2
    gain: '1.0'
    samp_rate: samp_rate
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: publisher_transition
  id: variable
  parameters:
    value: 500e3/4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 500e3/2
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(samp_rate/4-publisher_transition)'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/4-publisher_transition
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate/2
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate/2
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: big_low_pass
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: big_low_pass
    type: ccc
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.42.0.169:12345
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.42.0.169:12347
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_add_xx_0, '0', fosphor_qt_sink_c_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_xx_0_0, '1']
- [zeromq_sub_source_0, '0', fosphor_qt_sink_c_0, '0']
- [zeromq_sub_source_0, '0', interp_fir_filter_xxx_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', fosphor_qt_sink_c_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', interp_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
