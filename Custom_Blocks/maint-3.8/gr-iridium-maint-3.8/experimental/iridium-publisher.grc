options:
  parameters:
    author: schneider
    generate_options: no_gui
    id: iridium_publisher
    output_language: python
    run_options: run
    title: Iridium Publisher
  states: {}

blocks:
- name: big_low_pass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/4 - transition + transition /2
    gain: '1.0'
    samp_rate: samp_rate
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: int(math.pow(2, 1 + int(math.log(samp_rate / 1000, 2))))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 500e3/4
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: samp_rate/4-transition
    decim: '2'
    samp_rate: samp_rate
    taps: big_low_pass
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-(samp_rate/4-transition)'
    decim: '2'
    samp_rate: samp_rate
    taps: big_low_pass
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iridium_fft_burst_tagger_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: 8 * fft_size
    burst_pre_len: 2 * fft_size
    burst_width: int(40e3)
    center_frequency: 1622e6
    debug: 'False'
    fft_size: fft_size
    history_size: '512'
    max_bursts: '0'
    sample_rate: int(samp_rate)
    threshold: '7'
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 1622e6
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:12345
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:12347
    timeout: '100'
    type: complex
  states: {}

connections:
- [freq_xlating_fft_filter_ccc_0, '0', zeromq_pub_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', zeromq_pub_sink_0_0_0, '0']
- [iridium_fft_burst_tagger_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [iridium_fft_burst_tagger_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [osmosdr_source_0, '0', iridium_fft_burst_tagger_0, '0']

metadata:
  file_format: 1
