options:
  parameters:
    author: schneider
    generate_options: no_gui
    id: iridium_subscriber_demod
    output_language: python
    run_options: run
    title: Iridium Subscriber Demod
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: int(math.pow(2, 1 + int(math.log(samp_rate / 2  / 1000, 2))))
  states: {}
- name: input_filter
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate/2, 40e3/2, 40e3, 40)
  states: {}
- name: publisher_transition
  id: variable
  parameters:
    value: 500e3/4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: start_finder_filter
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 250000, 5e3, 10e3, 60)
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: 1622e6 + ( samp_rate/4-publisher_transition)
    freq_span: samp_rate/2
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: 1622e6 -( samp_rate/4-publisher_transition)
    freq_span: samp_rate/2
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iridium_burst_downmix_0_0
  id: iridium_burst_downmix
  parameters:
    handle_multiple_frames_per_burst: 'True'
    hard_max_queue_len: '1000'
    input_taps: input_filter
    sample_rate: int(samp_rate/2)
    search_depth: int(0.007 * 250000)
    start_finder_taps: start_finder_filter
  states: {}
- name: iridium_burst_downmix_0_0_0
  id: iridium_burst_downmix
  parameters:
    handle_multiple_frames_per_burst: 'True'
    hard_max_queue_len: '1000'
    input_taps: input_filter
    sample_rate: int(samp_rate/2)
    search_depth: int(0.007 * 250000)
    start_finder_taps: start_finder_filter
  states: {}
- name: iridium_fft_burst_tagger_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: 8 * fft_size
    burst_pre_len: 2 * fft_size
    burst_width: int(40e3)
    center_frequency: 1622e6 + samp_rate/4-publisher_transition
    debug: 'False'
    fft_size: fft_size
    history_size: '512'
    max_bursts: '0'
    sample_rate: int(samp_rate/2)
    threshold: '7'
  states: {}
- name: iridium_fft_burst_tagger_0_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: 8 * fft_size
    burst_pre_len: 2 * fft_size
    burst_width: int(40e3)
    center_frequency: 1622e6 -( samp_rate/4-publisher_transition)
    debug: 'False'
    fft_size: fft_size
    history_size: '512'
    max_bursts: '0'
    sample_rate: int(samp_rate/2)
    threshold: '7'
  states: {}
- name: iridium_frame_sorter_0
  id: iridium_frame_sorter
  parameters: {}
  states: {}
- name: iridium_iridium_frame_printer_0
  id: iridium_iridium_frame_printer
  parameters: {}
  states: {}
- name: iridium_iridium_qpsk_demod_cpp_0
  id: iridium_iridium_qpsk_demod_cpp
  parameters: {}
  states: {}
- name: iridium_tagged_burst_to_pdu_0
  id: iridium_tagged_burst_to_pdu
  parameters:
    drop_overflow: 'False'
    max_burst_size: int(samp_rate/2 * 0.09)
    max_outstanding: '500'
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
  states: {}
- name: iridium_tagged_burst_to_pdu_0_0
  id: iridium_tagged_burst_to_pdu
  parameters:
    drop_overflow: 'False'
    max_burst_size: int(samp_rate/2 * 0.09)
    max_outstanding: '500'
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.42.0.169:12345
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.42.0.169:12347
    timeout: '100'
    type: complex
  states: {}

connections:
- [iridium_burst_downmix_0_0, burst_handled, iridium_tagged_burst_to_pdu_0, burst_handled]
- [iridium_burst_downmix_0_0, cpdus, iridium_iridium_qpsk_demod_cpp_0, cpdus]
- [iridium_burst_downmix_0_0_0, burst_handled, iridium_tagged_burst_to_pdu_0_0, burst_handled]
- [iridium_burst_downmix_0_0_0, cpdus, iridium_iridium_qpsk_demod_cpp_0, cpdus]
- [iridium_fft_burst_tagger_0, '0', iridium_tagged_burst_to_pdu_0, '0']
- [iridium_fft_burst_tagger_0_0, '0', iridium_tagged_burst_to_pdu_0_0, '0']
- [iridium_frame_sorter_0, pdus, iridium_iridium_frame_printer_0, pdus]
- [iridium_iridium_qpsk_demod_cpp_0, pdus, iridium_frame_sorter_0, pdus]
- [iridium_tagged_burst_to_pdu_0, cpdus, iridium_burst_downmix_0_0, cpdus]
- [iridium_tagged_burst_to_pdu_0_0, cpdus, iridium_burst_downmix_0_0_0, cpdus]
- [zeromq_sub_source_0, '0', fosphor_qt_sink_c_0, '0']
- [zeromq_sub_source_0, '0', iridium_fft_burst_tagger_0, '0']
- [zeromq_sub_source_0_0_0, '0', fosphor_qt_sink_c_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', iridium_fft_burst_tagger_0_0, '0']

metadata:
  file_format: 1
