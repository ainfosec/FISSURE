options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: fm_rds_alternate
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: baseband_decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: baseband_sample_rate
  id: variable
  parameters:
    value: x_samp_rate / baseband_decim
  states: {}
- name: dgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,4
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '.48'
  states: {}
- name: fm_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,5
    label: FM Carrier Frequency
    orient: Qt.Horizontal
    start: 87.5e6
    step: 1e5
    stop: 108.e6
    value: 101.2e6
  states: {}
- name: rds_bit_rate
  id: variable
  parameters:
    comment: This RATE is fixed per Standard Definition.
    value: '1187.5'
  states: {}
- name: rds_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rds_sample_rate
  id: variable
  parameters:
    value: samples_per_symbol * rds_symbol_rate
  states: {}
- name: rds_symbol_rate
  id: variable
  parameters:
    value: symbols_per_bit * rds_bit_rate
  states: {}
- name: rrc_decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rrc_sample_rate
  id: variable
  parameters:
    value: rds_sample_rate * rrc_decim
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbols_per_bit
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_constellation_rect_0
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: x_decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: x_samp_rate
  id: variable
  parameters:
    value: samp_rate / x_decimation
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '.6e-1'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: baseband_decim
    quad_rate: x_samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: symbols_per_bit
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    bus_conns: '[[0,],]'
    num_inputs: '3'
    type: float
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '.25'
    fmin: '-.25'
    loop_bw: 4 * 6.28/100
    showports: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '55'
    rolloff: excess_bw
    samps_per_sym: samples_per_symbol
    type: cc
    w: .3 * 6.28/100
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 2 * 6.28/100
    max_dev: '1.5'
    osps: '1'
    sps: samples_per_symbol
    taps: firdes.root_raised_cosine(32, 32*7, 1.0, excess_bw, 11*7*32)
    type: ccf
  states: {}
- name: fm_stereo_audio_decoder_0
  id: fm_stereo_audio_decoder
  parameters:
    audio_rate: audio_rate
    baseband_rate: baseband_sample_rate
    volume: '-15.'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: x_decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100e3, 100e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: rds_decim
    samp_rate: baseband_sample_rate
    taps: firdes.low_pass(2500.0,baseband_sample_rate,2.2e3,2e3,firdes.WIN_HAMMING)
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@2:0,5,4,4
    name: '"RDS Constellation"'
    nconnections: '2'
    size: '256'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate/x_decimation
    ctrlpanel: 'True'
    fc: fm_freq
    fftsize: '4096'
    gui_hint: tabs@0:0,0,8,9
    legend: 'False'
    name: '"Radio Spectrum"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: baseband_sample_rate
    ctrlpanel: 'True'
    fc: '0.0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: tabs@1:0,0,8,9
    legend: 'False'
    name: '"FM demodulated spectrum"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: baseband_sample_rate / 5
    fc: '0.0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: tabs@3:0,0,4,4
    legend: 'False'
    name: '"L+R Spectrum"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: baseband_sample_rate / 5
    fc: '0.0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: tabs@3:0,4,4,4
    legend: 'False'
    name: '"L-R Spectrum"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: baseband_sample_rate
    fc: '0.0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: tabs@3:4,0,4,4
    legend: 'False'
    name: '"DSB-SC Spectrum"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: rrc_sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2:0,0,5,5
    label2: ''
    name: '"RDS Spectrum"'
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    grid: 'True'
    gui_hint: tabs@3:4,4,4,4
    label1: ''
    name: '"2x Pilot Tone"'
    size: '128'
    srate: baseband_sample_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(baseband_sample_rate / rds_decim)
    interp: int(rrc_sample_rate)
    taps: ''
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: rrc_decim
    gain: '1'
    ntaps: '100'
    samp_rate: rrc_sample_rate
    sym_rate: rds_symbol_rate
    type: fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: fm_freq
    gain0: dgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: ''
    type: fc32
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,9,9
    label0: RF Properties
    label1: FM Band
    label2: RDS
    label3: Audio
    num_tabs: '4'
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_wfm_rcv_0, '0', fm_stereo_audio_decoder_0, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [blocks_keep_one_in_n_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_keep_one_in_n_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '1']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_1, '1']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [fm_stereo_audio_decoder_0, '0', audio_sink_0_0, '0']
- [fm_stereo_audio_decoder_0, '1', audio_sink_0_0, '1']
- [fm_stereo_audio_decoder_0, '2', qtgui_freq_sink_x_0_0_0_1_0_1, '0']
- [fm_stereo_audio_decoder_0, '3', qtgui_time_sink_x_0, '0']
- [fm_stereo_audio_decoder_0, '4', qtgui_freq_sink_x_0_0_0_1_0, '0']
- [fm_stereo_audio_decoder_0, '5', qtgui_freq_sink_x_0_0_0_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [root_raised_cosine_filter_0, '0', analog_agc2_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
