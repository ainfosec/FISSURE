options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rds_loopback
    output_language: python
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: audio_decim_rate
  id: variable
  parameters:
    value: baseband_rate/audio_decim
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    value: samp_rate/bb_decim
  states: {}
- name: bb_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fm_max_dev
  id: variable
  parameters:
    value: 80e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88.0e6
    step: 0.1e6
    stop: 108.0e6
    value: 97e6
  states: {}
- name: input_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rds_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.02'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: stereo_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.3'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 19e3*20
  states: {}
- name: xlate_bandwidth
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: bb_decim
    quad_rate: samp_rate
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rds_gain
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '160'
    type: float
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1e6
    type: complex
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '2'
    differential: 'False'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '7'
    timing_bw: 6.28/100.0
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, xlate_bandwidth, 100000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: audio_decim
    samp_rate: baseband_rate
    taps: firdes.low_pass(2500.0,baseband_rate,2.4e3,2e3,firdes.WIN_HAMMING)
    type: fcc
  states: {}
- name: gr_char_to_float_0
  id: blocks_char_to_float
  parameters:
    maxoutbuf: outbuffer
    scale: '1'
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    maxoutbuf: outbuffer
    modulus: '2'
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: 2*math.pi*fm_max_dev/usrp_rate
  states: {}
- name: gr_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: gr_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 57e3
    offset: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
    maxoutbuf: outbuffer
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5e3
    gain: '1'
    interp: '1'
    maxoutbuf: outbuffer
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: .5e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    gui_hint: tabs@0
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate/5
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baseband_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '38'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 89.8e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: WDR 3
    pty: '14'
    pty_locale: '0'
    radiotext: GNU Radio <3
    ta: 'False'
    tp: 'True'
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '3'
    gain: '1'
    ntaps: '100'
    samp_rate: samp_rate/bb_decim/audio_decim
    sym_rate: '2375'
    type: fir_filter_ccf
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: BB
    label1: RDS
    label2: Waterfall
    num_tabs: '3'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', gr_frequency_modulator_fc_0, '0']
- [blocks_repeat_0, '0', low_pass_filter_0, '0']
- [blocks_socket_pdu_0, pdus, rds_encoder_0, rds in]
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_diff_decoder_bb_0_0, '0', rds_decoder_0, '0']
- [digital_psk_demod_0, '0', blocks_keep_one_in_n_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', root_raised_cosine_filter_0_0, '0']
- [gr_char_to_float_0, '0', blocks_repeat_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_frequency_modulator_fc_0, '0', rational_resampler_xxx_1, '0']
- [gr_map_bb_0, '0', gr_char_to_float_0, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [gr_sig_source_x_0_0, '0', gr_multiply_xx_0, '0']
- [gr_unpack_k_bits_bb_0, '0', gr_map_bb_0, '0']
- [low_pass_filter_0, '0', gr_multiply_xx_0, '1']
- [rational_resampler_xxx_1, '0', blocks_throttle_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [rds_parser_0, out, rds_panel_0, in]
- [root_raised_cosine_filter_0_0, '0', digital_psk_demod_0, '0']

metadata:
  file_format: 1
