options:
  parameters:
    author: Felix Wunsch
    category: '[IEEE802.15.4]'
    description: IEEE 802.15.4 CSS PHY
    generate_options: hb
    id: ieee802_15_4_css_phy
    output_language: python
    title: IEEE 802.15.4 CSS PHY
  states: {}

blocks:
- name: bits_per_cw
  id: parameter
  parameters:
    label: Bits per codeword
    type: intx
    value: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: sym_per_frame-len(preamble)-len(sfd)
    n: sym_per_frame
    offset: len(preamble)+len(sfd)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0_0_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: sym_per_frame-len(preamble)-len(sfd)
    n: sym_per_frame
    offset: len(preamble)+len(sfd)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*np.pi/4)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"burst_len"'
    packet_len: nsamp_frame
    type: complex
  states: {}
- name: chirp_seq
  id: parameter
  parameters:
    label: Chirp sequence
    value: '[]'
  states: {}
- name: codewords
  id: parameter
  parameters:
    label: Codewords
    value: '[[0,0],[1,1]]'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2 * math.pi / 100
  states: {}
- name: ieee802_15_4_codeword_mapper_bi_0
  id: ieee802_15_4_codeword_mapper_bi
  parameters:
    bits_per_cw: bits_per_cw
    codewords: codewords
  states: {}
- name: ieee802_15_4_codeword_mapper_bi_0_0
  id: ieee802_15_4_codeword_mapper_bi
  parameters:
    bits_per_cw: bits_per_cw
    codewords: codewords
  states: {}
- name: ieee802_15_4_codeword_soft_demapper_fb_0
  id: ieee802_15_4_codeword_soft_demapper_fb
  parameters:
    bits_per_cw: bits_per_cw
    codewords: codewords
  states: {}
- name: ieee802_15_4_codeword_soft_demapper_fb_0_0
  id: ieee802_15_4_codeword_soft_demapper_fb
  parameters:
    bits_per_cw: bits_per_cw
    codewords: codewords
  states: {}
- name: ieee802_15_4_deinterleaver_ff_0
  id: ieee802_15_4_deinterleaver_ff
  parameters:
    intlv_seq: intlv_seq
  states: {}
- name: ieee802_15_4_deinterleaver_ff_0_0
  id: ieee802_15_4_deinterleaver_ff
  parameters:
    intlv_seq: intlv_seq
  states: {}
- name: ieee802_15_4_dqcsk_mapper_fc_0
  id: ieee802_15_4_dqcsk_mapper_fc
  parameters:
    chirp_seq: chirp_seq
    len_subchirp: len_sub
    nsym_frame: sym_per_frame
    num_subchirps: num_subchirps
    time_gap_1: time_gap_1
    time_gap_2: time_gap_2
  states: {}
- name: ieee802_15_4_dqpsk_mapper_ff_0
  id: ieee802_15_4_dqpsk_mapper_ff
  parameters:
    forward: 'True'
    framelen: sym_per_frame
  states: {}
- name: ieee802_15_4_dqpsk_soft_demapper_cc_0
  id: ieee802_15_4_dqpsk_soft_demapper_cc
  parameters:
    framelen: sym_per_frame
  states: {}
- name: ieee802_15_4_frame_buffer_cc_0
  id: ieee802_15_4_frame_buffer_cc
  parameters:
    nsym_frame: sym_per_frame
  states: {}
- name: ieee802_15_4_interleaver_ii_0
  id: ieee802_15_4_interleaver_ii
  parameters:
    forward: 'True'
    intlv_seq: intlv_seq
  states: {}
- name: ieee802_15_4_interleaver_ii_0_0
  id: ieee802_15_4_interleaver_ii
  parameters:
    forward: 'True'
    intlv_seq: intlv_seq
  states: {}
- name: ieee802_15_4_multiuser_chirp_detector_cc_0
  id: ieee802_15_4_multiuser_chirp_detector_cc
  parameters:
    chirp_seq: chirp_seq
    len_subchirp: len_sub
    threshold: threshold
    time_gap_1: len(time_gap_1)
    time_gap_2: len(time_gap_2)
  states: {}
- name: ieee802_15_4_phr_prefixer_0
  id: ieee802_15_4_phr_prefixer
  parameters:
    phr: phr
  states: {}
- name: ieee802_15_4_phr_removal_0_0
  id: ieee802_15_4_phr_removal
  parameters:
    phr: phr
  states: {}
- name: ieee802_15_4_preamble_sfd_prefixer_ii_0
  id: ieee802_15_4_preamble_sfd_prefixer_ii
  parameters:
    nsym_frame: sym_per_frame
    preamble: preamble
    sfd: sfd
  states: {}
- name: ieee802_15_4_preamble_sfd_prefixer_ii_0_0
  id: ieee802_15_4_preamble_sfd_prefixer_ii
  parameters:
    nsym_frame: sym_per_frame
    preamble: preamble
    sfd: sfd
  states: {}
- name: ieee802_15_4_preamble_tagger_cc_0
  id: ieee802_15_4_preamble_tagger_cc
  parameters:
    len_preamble: len(preamble)
  states: {}
- name: ieee802_15_4_qpsk_mapper_if_0
  id: ieee802_15_4_qpsk_mapper_if
  parameters: {}
  states: {}
- name: ieee802_15_4_zeropadding_b_0
  id: ieee802_15_4_zeropadding_b
  parameters:
    nzeros: nzeros_padding
  states: {}
- name: ieee802_15_4_zeropadding_removal_b_0_0
  id: ieee802_15_4_zeropadding_removal_b
  parameters:
    nzeros: nzeros_padding
    phr_payload_len: nbytes_payload*8+len(phr)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: intlv_seq
  id: parameter
  parameters:
    label: Interleaver sequence
    value: '[]'
  states: {}
- name: len_sub
  id: parameter
  parameters:
    label: Samples per subchirp
    type: intx
    value: '1'
  states: {}
- name: nbytes_payload
  id: parameter
  parameters:
    label: Num payload bytes
    type: intx
    value: '127'
  states: {}
- name: nsamp_frame
  id: parameter
  parameters:
    label: Samples per frame
    type: long
    value: '1'
  states: {}
- name: num_subchirps
  id: parameter
  parameters:
    label: Num subchirps per sequence
    type: intx
    value: '1'
  states: {}
- name: nzeros_padding
  id: parameter
  parameters:
    label: Num padded zeros
    type: intx
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: txout
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: det_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: rxout
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: costas_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: framer_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: qpsk_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: rxin
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: txin
    type: message
  states: {}
- name: phr
  id: parameter
  parameters:
    label: PHR
    value: '[0 for i in range(12)]'
  states: {}
- name: preamble
  id: parameter
  parameters:
    label: Preamble
    value: ()
  states: {}
- name: sfd
  id: parameter
  parameters:
    label: SFD
    value: ()
  states: {}
- name: sym_per_frame
  id: parameter
  parameters:
    label: Symbols per frame
    value: '1'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    type: eng_float
    value: '0'
  states: {}
- name: time_gap_1
  id: parameter
  parameters:
    label: Time gap 1
    value: ()
  states: {}
- name: time_gap_2
  id: parameter
  parameters:
    label: Time gap 2
    value: ()
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_keep_m_in_n_0_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_keep_m_in_n_0_0_0_0, '0']
- [blocks_deinterleave_0, '0', ieee802_15_4_codeword_mapper_bi_0, '0']
- [blocks_deinterleave_0, '1', ieee802_15_4_codeword_mapper_bi_0_0, '0']
- [blocks_interleave_0_0, '0', ieee802_15_4_zeropadding_removal_b_0_0, '0']
- [blocks_keep_m_in_n_0_0_0, '0', ieee802_15_4_deinterleaver_ff_0, '0']
- [blocks_keep_m_in_n_0_0_0_0, '0', ieee802_15_4_deinterleaver_ff_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_4, '0']
- [blocks_stream_to_tagged_stream_0, '0', pad_sink_0, '0']
- [digital_costas_loop_cc_0, '0', ieee802_15_4_preamble_tagger_cc_0, '0']
- [digital_costas_loop_cc_0, '0', pad_sink_2, '0']
- [ieee802_15_4_codeword_mapper_bi_0, '0', ieee802_15_4_interleaver_ii_0, '0']
- [ieee802_15_4_codeword_mapper_bi_0_0, '0', ieee802_15_4_interleaver_ii_0_0, '0']
- [ieee802_15_4_codeword_soft_demapper_fb_0, '0', blocks_interleave_0_0, '1']
- [ieee802_15_4_codeword_soft_demapper_fb_0_0, '0', blocks_interleave_0_0, '0']
- [ieee802_15_4_deinterleaver_ff_0, '0', ieee802_15_4_codeword_soft_demapper_fb_0_0, '0']
- [ieee802_15_4_deinterleaver_ff_0_0, '0', ieee802_15_4_codeword_soft_demapper_fb_0, '0']
- [ieee802_15_4_dqcsk_mapper_fc_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [ieee802_15_4_dqpsk_mapper_ff_0, '0', ieee802_15_4_dqcsk_mapper_fc_0, '0']
- [ieee802_15_4_dqpsk_soft_demapper_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [ieee802_15_4_frame_buffer_cc_0, '0', ieee802_15_4_dqpsk_soft_demapper_cc_0, '0']
- [ieee802_15_4_frame_buffer_cc_0, '0', pad_sink_3, '0']
- [ieee802_15_4_interleaver_ii_0, '0', ieee802_15_4_preamble_sfd_prefixer_ii_0, '0']
- [ieee802_15_4_interleaver_ii_0_0, '0', ieee802_15_4_preamble_sfd_prefixer_ii_0_0, '0']
- [ieee802_15_4_multiuser_chirp_detector_cc_0, '0', digital_costas_loop_cc_0, '0']
- [ieee802_15_4_multiuser_chirp_detector_cc_0, '0', pad_sink_1, '0']
- [ieee802_15_4_phr_prefixer_0, out, ieee802_15_4_zeropadding_b_0, in]
- [ieee802_15_4_phr_removal_0_0, out, pad_sink_1_0, in0]
- [ieee802_15_4_preamble_sfd_prefixer_ii_0, '0', ieee802_15_4_qpsk_mapper_if_0, '0']
- [ieee802_15_4_preamble_sfd_prefixer_ii_0_0, '0', ieee802_15_4_qpsk_mapper_if_0, '1']
- [ieee802_15_4_preamble_tagger_cc_0, '0', ieee802_15_4_frame_buffer_cc_0, '0']
- [ieee802_15_4_qpsk_mapper_if_0, '0', ieee802_15_4_dqpsk_mapper_ff_0, '0']
- [ieee802_15_4_zeropadding_b_0, '0', blocks_deinterleave_0, '0']
- [ieee802_15_4_zeropadding_removal_b_0_0, out, ieee802_15_4_phr_removal_0_0, in]
- [pad_source_0, '0', ieee802_15_4_multiuser_chirp_detector_cc_0, '0']
- [pad_source_1, out0, ieee802_15_4_phr_prefixer_0, in]

metadata:
  file_format: 1
