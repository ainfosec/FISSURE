options:
  parameters:
    generate_options: qt_gui
    id: tpms_rx
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    orient: Qt.Horizontal
    start: 2395e6
    step: '10000'
    stop: 2405e6
    value: 2400e6
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    orient: Qt.Horizontal
    start: 314e6
    step: '10000'
    stop: 316e6
    value: 315e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '40'
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: rx_usrp_frequency
  id: variable
  parameters:
    value: 2400e6
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: '[3,0,1,1]'
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '5'
    value: '0.5'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0'
    max_gain: '20'
    rate: '0.05'
    reference: '1'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sample_rate/(2*math.pi*80000/8.0)
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '50'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user1/Out-of-Tree_Modules/gr-tpms_poore-maint-3.8/examples/prius_front_left_bad5_cropped.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '20'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-4'
    init: '0'
    low: '-4'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 4*[0.25]
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[-0.0008305677911266685,1.273209426936268e-18,0.000956247269641608,0.0017532981000840664,0.002036140998825431,0.001484151929616928,-2.205767886444876e-18,-0.0021032134536653757,-0.0040522413328289986,-0.0048095667734742165,-0.0035121184773743153,4.300930558053143e-18,0.0048276749439537525,0.009086896665394306,0.01051908079534769,0.007491897791624069,-7.166095602757168e-18,-0.00983386766165495,-0.018142474815249443,-0.020635876804590225,-0.01448017917573452,1.0264376687690889e-17,0.01861647516489029,0.03416387736797333,0.038804732263088226,0.02731286734342575,-1.3015203037863547e-17,-0.0359332337975502,-0.06745827943086624,-0.0792057141661644,-0.05845359340310097,1.4903114573020887e-17,0.09084675461053848,0.19842340052127838,0.30026140809059143,0.37310129404067993,0.39952942728996277,0.37310129404067993,0.30026140809059143,0.19842340052127838,0.09084675461053848,1.4903114573020887e-17,-0.05845359340310097,-0.0792057141661644,-0.06745827943086624,-0.0359332337975502,-1.3015203037863547e-17,0.02731286734342575,0.038804732263088226,0.03416387736797333,0.01861647516489029,1.0264376687690889e-17,-0.01448017917573452,-0.020635876804590225,-0.018142474815249443,-0.00983386766165495,-7.166095602757168e-18,0.007491897791624069,0.01051908079534769,0.009086896665394306,0.0048276749439537525,4.300930558053143e-18,-0.0035121184773743153,-0.0048095667734742165,-0.0040522413328289986,-0.0021032134536653757,-2.205767886444876e-18,0.001484151929616928,0.002036140998825431,0.0017532981000840664,0.000956247269641608,1.273209426936268e-18,-0.0008305677911266685]'
    type: ccc
  states: {state: disabled}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 50*[0.02]
    type: fff
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[4,0,1,1]'
    label1: ''
    label2: ''
    size: '200000'
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '40000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: '[6,0,1,1]'
    label1: ''
    size: '10000'
    srate: '1'
    type: float
    ymax: '1.2'
    ymin: '-.2'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5,0,1,1]'
    label1: ''
    size: '200000'
    srate: '1'
    type: float
    ymax: '4'
    ymin: '-.1'
  states: {}
- name: tpms_poore_decoder_0
  id: tpms_poore_decoder
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [analog_agc_xx_0, '0', blocks_delay_1, '0']
- [analog_agc_xx_0, '0', fir_filter_xxx_1, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [blocks_burst_tagger_1, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_1, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_keep_one_in_n_0, '0', tpms_poore_decoder_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_short_1, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_delay_1, '0']
- [fir_filter_xxx_1_0, '0', blocks_threshold_ff_0_0, '0']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0_2, '0']
- [osmosdr_source_0, '0', analog_agc_xx_0, '0']
- [tpms_poore_decoder_0, out, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
