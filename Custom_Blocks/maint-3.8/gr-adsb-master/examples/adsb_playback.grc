<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>adsb_playback</value></param>
<param><key>author</key><value>Matt Hostetter</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>ADS-B Playback</value></param>
</block>
<block>
<key>adsb_decoder</key>
<param><key>id</key><value>adsb_decoder_0</value></param>
<param><key>error_corr</key><value>"None"</value></param>
<param><key>msg_filter</key><value>"Extended Squitter Only"</value></param>
<param><key>print_level</key><value>"Brief"</value></param>
</block>
<block>
<key>sqlite_timed_source</key>
<param><key>id</key><value>sqlite_timed_source_0</value></param>
<param><key>filename</key><value>/home/matt/adsb.db</value></param>
<param><key>vector_column_name</key><value>data</value></param>
<param><key>realtime_factor</key><value>1.0</value></param>
<param><key>db_start_timestamp</key><value>None</value></param>
<param><key>table_name</key><value>demodulated</value></param>
<param><key>timestamp_column_name</key><value>timestamp</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5001</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<connection><source_block_id>adsb_decoder_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>decoded</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sqlite_timed_source_0</source_block_id><sink_block_id>adsb_decoder_0</sink_block_id><source_key>pdu</source_key><sink_key>demodulated</sink_key></connection>
</flow_graph>
