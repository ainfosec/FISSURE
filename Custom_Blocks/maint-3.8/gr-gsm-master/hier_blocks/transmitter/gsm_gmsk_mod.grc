<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gsm_gmsk_mod</value></param>
<param><key>author</key><value>Piotr Krysik</value></param>
<param><key>category</key><value>Modulators</value></param>
<param><key>description</key><value>GMSK Modulator for GSM</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GMSK Modulator for GSM</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>BT</value></param>
<param><key>label</key><value>3 dB Time-Bandwidth Product</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>sps</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>[1,-1]</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_gmskmod_bc</key>
<param><key>id</key><value>digital_gmskmod_bc_0</value></param>
<param><key>bt</key><value>BT</value></param>
<param><key>L</key><value>pulse_duration</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio.analog import cpm</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pulse_duration</value></param>
<param><key>label</key><value>Pulse Duration</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples/Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>digital_gmskmod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmskmod_bc_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
