<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>clock_offset_corrector_tagged</value></param>
<param><key>author</key><value>Piotr Krysik</value></param>
<param><key>category</key><value>GSM</value></param>
<param><key>description</key><value>Clock offset corrector with blocks that use tags to switch offsets</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Clock Offset Corrector Tagged</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gsm_symb_rate</value></param>
<param><key>value</key><value>1625000.0/6.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>value</key><value>osr*gsm_symb_rate</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>ctrl</value></param>
<param><key>label</key><value>ctrl</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>936.6e6</value></param>
</block>
<block>
<key>gsm_controlled_fractional_resampler_cc</key>
<param><key>id</key><value>gsm_controlled_fractional_resampler_cc_0</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>(1-ppm/1.0e6)*(samp_rate_in/samp_rate_out)</value></param>
</block>
<block>
<key>gsm_controlled_rotator_cc</key>
<param><key>id</key><value>gsm_controlled_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>ppm/1.0e6*2*math.pi*fc/samp_rate_out</value></param>
</block>
<block>
<key>gsm_msg_to_tag</key>
<param><key>id</key><value>gsm_msg_to_tag_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>math_imp</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OSR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_in</value></param>
<param><key>label</key><value>samp_rate_in</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1625000.0/6.0*4.0</value></param>
</block>
<connection><source_block_id>ctrl</source_block_id><sink_block_id>gsm_msg_to_tag_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>gsm_controlled_fractional_resampler_cc_0</source_block_id><sink_block_id>gsm_controlled_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_controlled_rotator_cc_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_msg_to_tag_0</source_block_id><sink_block_id>gsm_controlled_fractional_resampler_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gsm_msg_to_tag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
