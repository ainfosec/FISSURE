<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_address</value></param>
<param><key>value</key><value>"192.168.40.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1928.448e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>1924.992e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1921.536e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_sampling_rate</value></param>
<param><key>value</key><value>1*100000000/32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1923.264e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampler_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, 3*baseband_sampling_rate, dect_occupied_bandwidth/2, (dect_channel_bandwidth - dect_occupied_bandwidth)/2, 30)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dect_channel_bandwidth</value></param>
<param><key>value</key><value>1.728e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dect_occupied_bandwidth</value></param>
<param><key>value</key><value>1.2*dect_symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dect_symbol_rate</value></param>
<param><key>value</key><value>1152000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>3125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_antenna</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_channel</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1926.720e6</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0</value></param>
<param><key>rx_id</key><value>part_id</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>"addr="+ip_address</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>baseband_sampling_rate</value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Carrier Number</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>1897344000</value></param>
<param><key>options</key><value>[1897344000, 1881792000, 1883520000, 1885248000, 1886876000, 1888704000, 1890432000, 1892160000, 1893888000, 1895616000, 1921.536e6, 1923.264e6, 1924.992e6, 1926.720e6, 1928.448e6]</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8", "9", "DECT1","DECT2","DECT3","DECT4","DECT5"]</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>(0,1)</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024*8</value></param>
<param><key>srate</key><value>baseband_sampling_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>dect2_packet_receiver</key>
<param><key>id</key><value>dect2_packet_receiver_0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>baseband_sampling_rate</value></param>
<param><key>ymax</key><value>-40</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>rational_resampler_base_xxx</key>
<param><key>id</key><value>rational_resampler</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>3</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value>resampler_filter_taps</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>(3.0*baseband_sampling_rate/2.0)/dect_symbol_rate/4.0</value></param>
</block>
<block>
<key>dect2_phase_diff</key>
<param><key>id</key><value>dect2_phase_diff_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>baseband_sampling_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>m</key><value>384</value></param>
<param><key>n</key><value>388</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>pcap_fifo</key>
<param><key>id</key><value>pcap_fifo_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(0,0,0,0,0,0,170,170,170,233,138)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengths</key><value>11, 48</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>59</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>rational_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler</source_block_id><sink_block_id>fractional_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0</source_block_id><sink_block_id>vocoder_g721_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0</source_block_id><sink_block_id>console_0</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_phase_diff_0</source_block_id><sink_block_id>dect2_packet_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_phase_diff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler</source_block_id><sink_block_id>dect2_phase_diff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pcap_fifo_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
