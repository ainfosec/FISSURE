<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>strongest</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>filepath</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>int(samples)*5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>float(sample_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import time

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, vec_len=8192, peak_detect_file="/tmp/indexes.data", fft_threshold=-80, sample_rate=1000000):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Embedded Python Block',   # will show up in GRC
            in_sig=[(np.float32,vec_len)],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.peak_detect_file=peak_detect_file
        self.fft_threshold=fft_threshold
        self.vec_len=vec_len
        self.sample_rate=sample_rate
        self.max_value=-100
        self.max_index=-1
        print("Starting Frequency Detection")


    def work(self, input_items,output_items):
        over_threshold = input_items[0][0][np.nonzero(input_items[0][0] &gt; self.fft_threshold)]
        if len(over_threshold) &gt; 0:
            if over_threshold.max() &gt; self.max_value:
                self.max_value = over_threshold.max()
                self.max_index = input_items[0][0].argmax()
                print("Strongest Freq.: " + str(self.max_value) + ' (dB), ' + str(self.max_index) + ' (bin), ' + str(float(self.max_index/self.vec_len)*self.sample_rate-float(self.sample_rate/2)) + " (Hz)")
            
                with open(self.peak_detect_file,'w') as fobj:
                    fobj.write(str(float(self.max_index/self.vec_len)*self.sample_rate-float(self.sample_rate/2)))
        return len(input_items[0])
</value></param>
<param><key>fft_threshold</key><value>float(fft_threshold)</value></param>
<param><key>peak_detect_file</key><value>str(peak_file_location)</value></param>
<param><key>sample_rate</key><value>float(sample_rate)</value></param>
<param><key>vec_len</key><value>int(fft_size)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>fft_size</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"8192"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_threshold</value></param>
<param><key>label</key><value>fft_threshold</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"-80"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filepath</value></param>
<param><key>label</key><value>filepath</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>fft_size</key><value>int(fft_size)</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>float(sample_rate)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>peak_file_location</value></param>
<param><key>label</key><value>peak_file_location</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>label</key><value>sample_rate</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"1e6"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samples</value></param>
<param><key>label</key><value>sampes</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"4169300"</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
