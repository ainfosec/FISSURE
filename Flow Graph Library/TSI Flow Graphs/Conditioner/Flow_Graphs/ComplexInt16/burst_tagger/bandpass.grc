options:
  parameters:
    generate_options: no_gui
    id: bandpass
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,1]'
    start: '0'
    step: '.001'
    stop: '1'
    value: '0.002'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: float(beta)
    decim: '1'
    gain: '1'
    high_cutoff_freq: float(bandpass_freq)+float(bandpass_width)/2
    low_cutoff_freq: float(bandpass_freq)-float(bandpass_width)/2
    samp_rate: float(sample_rate)
    type: fir_filter_ccf
    width: float(bandpass_width)/10
    win: window.WIN_HAMMING
  states: {}
- name: bandpass_freq
  id: parameter
  parameters:
    label: bandpass_freq
    type: str
    value: '100000'
  states: {}
- name: bandpass_width
  id: parameter
  parameters:
    label: bandpass_width
    type: str
    value: '100000'
  states: {}
- name: beta
  id: parameter
  parameters:
    label: beta
    type: str
    value: '6.76'
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '50'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/CLANKER/Data/tpms/four_tires2.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(float(sample_rate))
    type: short
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: float(threshold)
    init: '0'
    low: float(threshold)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(sample_rate)
    type: complex
  states: {}
- name: filepath
  id: parameter
  parameters:
    label: filepath
    type: str
    value: '"/home/user/Conditioner/Data/tpms/four_tires2.iq"'
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 50*[0.02]
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: float(sample_rate)
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: float(sample_rate)
    type: float
  states: {state: disabled}
- name: sample_rate
  id: parameter
  parameters:
    label: sample_rate
    type: str
    value: 1e6
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: threshold
    type: str
    value: '.002'
  states: {}
- name: transition_width
  id: parameter
  parameters:
    label: transition_width
    type: str
    value: 10e3
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [band_pass_filter_0, '0', blocks_delay_1, '0']
- [blocks_burst_tagger_1, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_1, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_short_1, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_threshold_ff_0_0, '0']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
