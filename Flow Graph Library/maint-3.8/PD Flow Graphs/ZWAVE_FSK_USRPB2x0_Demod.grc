options:
  parameters:
    generate_options: no_gui
    id: ZWAVE_FSK_USRPB2x0_Demod
    output_language: python
  states: {}

blocks:
- name: notes
  id: variable
  parameters:
    value: '"Decodes Z-Wave messages and prints the output. Tested against a Monoprice Z-Wave Plus RGB Smart Bulb."'
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: rx_usrp_frequency
  id: variable
  parameters:
    value: 916e6
  states: {}
- name: rx_usrp_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '50'
  states: {state: disabled}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: zmq_port
  id: variable
  parameters:
    value: '5066'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sample_rate/(2*math.pi*80000/8.0)
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Corrects synchronization issues for file source
    delay: '0'
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '20'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/FISSURE/Custom_Blocks/maint-3.7/gr-zwave_poore/examples/zwave_green_916_1MSps.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '350000'
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '.004'
    init: '0'
    low: '.004'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 4*[0.25]
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 20*[0.05]
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '40000'
    srate: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '350000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '350000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_usrp_frequency
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: serial
    dev_args: '""'
    gain0: rx_usrp_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: '"tcp://*:" + str(zmq_port)'
    timeout: '100'
  states: {}
- name: zwave_poore_decoder_0
  id: zwave_poore_decoder
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [blocks_burst_tagger_1, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_delay_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_1, '0']
- [blocks_file_source_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_delay_1, '0']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_head_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_head_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_keep_one_in_n_0, '0', zwave_poore_decoder_0, '0']
- [blocks_threshold_ff_0, '0', blocks_delay_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_short_1, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_threshold_ff_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_1, '0']
- [zwave_poore_decoder_0, bytes, zeromq_pub_msg_sink_0, in]
- [zwave_poore_decoder_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
