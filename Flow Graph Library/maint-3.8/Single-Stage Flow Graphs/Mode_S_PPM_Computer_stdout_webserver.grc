options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Mode_S_PPM_Computer_stdout_webserver
    output_language: python
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '"/home/laptop1/Documents/ads-b_signals/airport/adsb.iq"'
  states: {state: disabled}
- name: ip_address
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {state: disabled}
- name: notes
  id: variable
  parameters:
    value: '"Forwards formatted decoded ADSB data (gr-adsb) originating from an IQ file to a webserver (tcp://127.0.0.1:5001) over ZMQ."'
  states: {}
- name: port
  id: variable
  parameters:
    value: '5001'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {state: disabled}
- name: threshold
  id: variable
  parameters:
    value: '0.01'
  states: {state: disabled}
- name: adsb_decoder_0_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"All Messages"'
    print_level: '"Verbose"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: float(samp_rate)
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: float(samp_rate)
    threshold: float(threshold)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '.01'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: str(filepath)
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(samp_rate)
    type: complex
  states: {}
- name: filepath
  id: parameter
  parameters:
    type: str
    value: '"/home/laptop1/Documents/ads-b_signals/airport/adsb.iq"'
  states: {}
- name: ip_address
  id: parameter
  parameters:
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: port
  id: parameter
  parameters:
    type: str
    value: '5001'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: '10000'
    srate: '1'
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    type: str
    value: 2e6
  states: {}
- name: threshold
  id: parameter
  parameters:
    type: str
    value: '0.01'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: '"tcp://" + str(ip_address) + ":" + str(port)'
    timeout: '10'
  states: {}

connections:
- [adsb_decoder_0_0, decoded, blocks_message_debug_0, store]
- [adsb_decoder_0_0, decoded, zeromq_pub_msg_sink_0_0, in]
- [adsb_demod_0, '0', blocks_null_sink_0, '0']
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [adsb_framer_1, '0', qtgui_time_sink_x_1_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
