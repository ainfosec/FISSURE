options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: General_General_USRPB2x0_IQ_Record_Squelch
    output_language: python
    run_options: run
  states: {}

blocks:
- name: file_length
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Records an IQ file for a specified number of samples following a power squelch."'
  states: {}
- name: rx_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: rx_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 2412e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: squelch_alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: squelch_ramp
  id: variable
  parameters:
    value: '100'
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: float(squelch_alpha)
    gate: 'True'
    ramp: int(squelch_ramp)
    threshold: float(squelch_threshold)
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: file_length
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '200000'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_antenna
    center_freq0: float(rx_frequency)
    dc_offs_enb0: '""'
    dev_addr: serial
    dev_args: '""'
    gain0: float(rx_gain)
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: float(sample_rate)
    sd_spec0: rx_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', analog_pwr_squelch_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
