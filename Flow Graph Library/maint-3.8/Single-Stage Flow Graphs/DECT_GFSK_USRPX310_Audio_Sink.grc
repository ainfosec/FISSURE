options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: DECT_GFSK_USRPX310_Audio_Sink
    output_language: python
  states: {}

blocks:
- name: baseband_sampling_rate
  id: variable
  parameters:
    value: '3125000'
  states: {}
- name: dect_channel_bandwidth
  id: variable
  parameters:
    value: 1.728e6
  states: {}
- name: dect_occupied_bandwidth
  id: variable
  parameters:
    value: '1382400'
  states: {}
- name: dect_symbol_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Plays DECT audio using gr-dect2 blocks."'
  states: {}
- name: part_id
  id: variable_qtgui_chooser
  parameters:
    label: Select Part
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7, 8]'
    type: int
    value: int(1)
  states: {state: disabled}
- name: part_id
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_freq
  id: variable_qtgui_chooser
  parameters:
    label: Carrier Number
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8", "9", "DECT1","DECT2","DECT3","DECT4","DECT5"]'
    num_opts: '0'
    options: '[1897344000, 1881792000, 1883520000, 1885248000, 1886876000, 1888704000, 1890432000, 1892160000, 1893888000, 1895616000, 1921.536e6, 1923.264e6, 1924.992e6, 1926.720e6, 1928.448e6]'
    type: real
    value: '1897344000'
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: 1923.264e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '3125000'
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: console_0
  id: console
  parameters: {}
  states: {state: disabled}
- name: dect2_packet_decoder_0
  id: dect2_packet_decoder
  parameters:
    rx_id: int(part_id)
  states: {}
- name: dect2_packet_receiver_0
  id: dect2_packet_receiver
  parameters: {}
  states: {}
- name: dect2_phase_diff_0
  id: dect2_phase_diff
  parameters: {}
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: (3.0*baseband_sampling_rate/2.0)/dect_symbol_rate/4.0
    type: complex
  states: {}
- name: rational_resampler
  id: rational_resampler_base_xxx
  parameters:
    decim: '2'
    interp: '3'
    taps: firdes.low_pass_2(1, 3*baseband_sampling_rate, dect_occupied_bandwidth/2, (dect_channel_bandwidth - dect_occupied_bandwidth)/2, 30)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '"addr="+ip_address'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: baseband_sampling_rate
    sync: sync
    type: fc32
  states: {}
- name: vocoder_g721_decode_bs_0
  id: vocoder_g721_decode_bs
  parameters: {}
  states: {}

connections:
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [dect2_packet_decoder_0, '0', vocoder_g721_decode_bs_0, '0']
- [dect2_packet_decoder_0, log_out, console_0, in]
- [dect2_packet_receiver_0, '0', dect2_packet_decoder_0, '0']
- [dect2_packet_receiver_0, rcvr_msg_out, dect2_packet_decoder_0, rcvr_msg_in]
- [dect2_phase_diff_0, '0', dect2_packet_receiver_0, '0']
- [mmse_resampler_xx_0, '0', dect2_phase_diff_0, '0']
- [rational_resampler, '0', mmse_resampler_xx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler, '0']
- [vocoder_g721_decode_bs_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
