<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ZWAVE_FSK_USRPB205mini_RandomColors</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>command</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"0163"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>command_class</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"26"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>configuration</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_node_id</value></param>
<param><key>value</key><value>"02"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_control</value></param>
<param><key>value</key><value>"4108"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>home_id</value></param>
<param><key>value</key><value>"fa1c0b48"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg_length</value></param>
<param><key>comment</key><value>Home ID through CRC</value></param>
<param><key>value</key><value>24</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>notes</value></param>
<param><key>value</key><value>"Randomly generates a new RGB value for each message. Tested against a Monoprice Z-Wave Plus RGB Smart Bulb."</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>repetition_interval</value></param>
<param><key>value</key><value>.15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>serial</value></param>
<param><key>value</key><value>"False"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_node_id</value></param>
<param><key>value</key><value>"01"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>string_variables</value></param>
<param><key>value</key><value>["home_id","source_node_id","frame_control","destination_node_id"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>916e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*80000/8.0)</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>comment</key><value>on/off</value></param>
<param><key>delay</key><value>(10*8*(26+14+4))-24</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>comment</key><value>colors</value></param>
<param><key>delay</key><value>(10*8*(26+msg_length+4))-24</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>2*10*8*(26+msg_length+4)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>comment</key><value>on/off</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>10*8*(26+14+4)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>comment</key><value>colors</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>10*8*(26+msg_length+4)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>digital_gfsk_mod</key>
<param><key>id</key><value>digital_gfsk_mod_0</value></param>
<param><key>bt</key><value>0.65</value></param>
<param><key>samples_per_symbol</key><value>10</value></param>
<param><key>sensitivity</key><value>0.25</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>100</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>100</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_1_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>serial</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>zwave_poore_message_generator_pdu</key>
<param><key>id</key><value>zwave_poore_message_generator_pdu_0</value></param>
<param><key>command_class</key><value>command_class</value></param>
<param><key>command</key><value>command</value></param>
<param><key>comment</key><value>on</value></param>
<param><key>configuration</key><value>1</value></param>
<param><key>destination_node_id</key><value>destination_node_id</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_control</key><value>frame_control</value></param>
<param><key>home_id</key><value>home_id</value></param>
<param><key>repetition_interval</key><value>repetition_interval</value></param>
<param><key>source_node_id</key><value>source_node_id</value></param>
</block>
<block>
<key>zwave_poore_message_generator_pdu</key>
<param><key>id</key><value>zwave_poore_message_generator_pdu_0_0</value></param>
<param><key>command_class</key><value>"26"</value></param>
<param><key>command</key><value>"0100"</value></param>
<param><key>comment</key><value>off</value></param>
<param><key>configuration</key><value>1</value></param>
<param><key>destination_node_id</key><value>"02"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_control</key><value>"4108"</value></param>
<param><key>home_id</key><value>home_id</value></param>
<param><key>repetition_interval</key><value>repetition_interval</value></param>
<param><key>source_node_id</key><value>source_node_id</value></param>
</block>
<block>
<key>zwave_poore_message_generator_pdu</key>
<param><key>id</key><value>zwave_poore_message_generator_pdu_0_0_0_0_0_0</value></param>
<param><key>command_class</key><value>"33"</value></param>
<param><key>command</key><value>"050500000100020003ff0400"</value></param>
<param><key>comment</key><value>green</value></param>
<param><key>configuration</key><value>1</value></param>
<param><key>destination_node_id</key><value>"02"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_control</key><value>"4108"</value></param>
<param><key>home_id</key><value>home_id</value></param>
<param><key>repetition_interval</key><value>repetition_interval</value></param>
<param><key>source_node_id</key><value>source_node_id</value></param>
</block>
<block>
<key>zwave_poore_message_generator_pdu</key>
<param><key>id</key><value>zwave_poore_message_generator_pdu_0_0_0_0_0_0_0</value></param>
<param><key>command_class</key><value>"33"</value></param>
<param><key>command</key><value>"0505000001000240039c0400"</value></param>
<param><key>comment</key><value>color_list</value></param>
<param><key>configuration</key><value>2</value></param>
<param><key>destination_node_id</key><value>destination_node_id</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_control</key><value>frame_control</value></param>
<param><key>home_id</key><value>home_id</value></param>
<param><key>repetition_interval</key><value>repetition_interval</value></param>
<param><key>source_node_id</key><value>source_node_id</value></param>
</block>
<block>
<key>zwave_poore_message_generator_pdu</key>
<param><key>id</key><value>zwave_poore_message_generator_pdu_0_0_0_0_0_0_0_0</value></param>
<param><key>command_class</key><value>"33"</value></param>
<param><key>command</key><value>"0505000001000240039c0400"</value></param>
<param><key>comment</key><value>random</value></param>
<param><key>configuration</key><value>3</value></param>
<param><key>destination_node_id</key><value>destination_node_id</value></param>
<param><key>frame_control</key><value>frame_control</value></param>
<param><key>home_id</key><value>home_id</value></param>
<param><key>repetition_interval</key><value>repetition_interval</value></param>
<param><key>source_node_id</key><value>source_node_id</value></param>
</block>
<block>
<key>zwave_poore_message_generator_pdu</key>
<param><key>id</key><value>zwave_poore_message_generator_pdu_0_0_0_0_0_0_1</value></param>
<param><key>command_class</key><value>"33"</value></param>
<param><key>command</key><value>"0505000001000200030004ff"</value></param>
<param><key>comment</key><value>green</value></param>
<param><key>configuration</key><value>1</value></param>
<param><key>destination_node_id</key><value>"02"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_control</key><value>"4108"</value></param>
<param><key>home_id</key><value>home_id</value></param>
<param><key>repetition_interval</key><value>repetition_interval</value></param>
<param><key>source_node_id</key><value>source_node_id</value></param>
</block>
<block>
<key>zwave_poore_message_generator_pdu</key>
<param><key>id</key><value>zwave_poore_message_generator_pdu_0_0_0_1</value></param>
<param><key>command_class</key><value>command_class</value></param>
<param><key>command</key><value>command</value></param>
<param><key>comment</key><value>red</value></param>
<param><key>configuration</key><value>1</value></param>
<param><key>destination_node_id</key><value>destination_node_id</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_control</key><value>frame_control</value></param>
<param><key>home_id</key><value>home_id</value></param>
<param><key>repetition_interval</key><value>repetition_interval</value></param>
<param><key>source_node_id</key><value>source_node_id</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_gfsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>uhd_usrp_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>uhd_usrp_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_mod_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zwave_poore_message_generator_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zwave_poore_message_generator_pdu_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zwave_poore_message_generator_pdu_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zwave_poore_message_generator_pdu_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zwave_poore_message_generator_pdu_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zwave_poore_message_generator_pdu_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zwave_poore_message_generator_pdu_0_0_0_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
