options:
  parameters:
    generate_options: no_gui
    id: ZWAVE_FSK_PlutoSDR_Transmit
    output_language: python
  states: {}

blocks:
- name: command
  id: variable
  parameters:
    value: '"05050000010002ff03000400"'
  states: {}
- name: command_class
  id: variable
  parameters:
    value: '"33"'
  states: {}
- name: configuration
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: destination_node_id
  id: variable
  parameters:
    value: '"02"'
  states: {}
- name: frame_control
  id: variable
  parameters:
    value: '"410d"'
  states: {}
- name: home_id
  id: variable
  parameters:
    value: '"fa1c0b48"'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.2.1"'
  states: {}
- name: msg_length
  id: variable
  parameters:
    comment: Home ID through CRC
    value: '24'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Transmits a Z-Wave message (default is a red light). Tested against a Monoprice Z-Wave Plus RGB Smart Bulb."'
  states: {}
- name: repetition_interval
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: source_node_id
  id: variable
  parameters:
    value: '"01"'
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["home_id","source_node_id","frame_control","destination_node_id","command_class","command"]'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 916e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '64'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*80000/8.0)
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: on/off
    delay: (10*8*(26+14+4))-24
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: colors
    delay: (10*8*(26+msg_length+4))-24
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 2*10*8*(26+msg_length+4)
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: on/off
    len_tag_key: '"packet_len"'
    packet_len: 10*8*(26+14+4)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: colors
    len_tag_key: '"packet_len"'
    packet_len: 10*8*(26+msg_length+4)
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.65'
    samples_per_symbol: '10'
    sensitivity: '0.25'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 89.75 - tx_gain
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(tx_freq)
    samplerate: int(samp_rate)
    uri: '"ip:" + str(ip_address)'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '20000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    size: '20000'
    srate: '1'
    type: complex
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0163"'
    command_class: '"26"'
    comment: 'on'
    configuration: '1'
    destination_node_id: '"02"'
    frame_control: '"4107"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0100"'
    command_class: '"26"'
    comment: 'off'
    configuration: '1'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"050500000100020003ff0400"'
    command_class: '"33"'
    comment: green
    configuration: '1'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0505000001000240039c0400"'
    command_class: '"33"'
    comment: color_list
    configuration: '2'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0505000001000240039c0400"'
    command_class: '"33"'
    comment: random
    configuration: '3'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0_1
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0505000001000200030004ff"'
    command_class: '"33"'
    comment: green
    configuration: '1'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_1
  id: zwave_poore_message_generator_pdu
  parameters:
    command: command
    command_class: command_class
    comment: red
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: frame_control
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_head_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_tag_gate_0, '0', blocks_delay_0, '0']
- [blocks_tag_gate_0, '0', blocks_delay_0_0, '0']
- [digital_gfsk_mod_0, '0', blocks_tag_gate_0, '0']
- [zwave_poore_message_generator_pdu_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0_1, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_1, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
