options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Mode_S_PPM_USRPB210_stdout_webserver
    output_language: python
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {state: disabled}
- name: channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '70'
  states: {state: disabled}
- name: notes
  id: variable
  parameters:
    value: '"Forwards formatted decoded ADSB data (gr-adsb) originating from an SDR (2 MS/s) to a webserver (tcp://127.0.0.1:5001) over ZMQ."'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {state: disabled}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {state: disabled}
- name: threshold
  id: variable
  parameters:
    value: '0.01'
  states: {state: disabled}
- name: adsb_decoder_0_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"All Messages"'
    print_level: '"Verbose"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: float(samp_rate)
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: float(samp_rate)
    threshold: float(threshold)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '.01'
    type: float
  states: {state: disabled}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '"TX/RX"'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/laptop1/Documents/ads-b_signals/airport/adsb.iq
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: channel
  id: parameter
  parameters:
    type: str
    value: '"A:A"'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: str
    value: 1090e6
  states: {}
- name: gain
  id: parameter
  parameters:
    type: str
    value: '70'
  states: {}
- name: ip_address
  id: parameter
  parameters:
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: port
  id: parameter
  parameters:
    type: str
    value: '5001'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: '10000'
    srate: '1'
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    type: str
    value: 2e6
  states: {}
- name: serial
  id: parameter
  parameters:
    type: str
    value: '"False"'
  states: {}
- name: threshold
  id: parameter
  parameters:
    type: str
    value: '0.01'
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: str(antenna)
    center_freq0: float(freq)
    dc_offs_enb0: '""'
    dev_addr: str(serial)
    dev_args: '""'
    gain0: float(gain)
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: float(samp_rate)
    sd_spec0: str(channel)
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: '"tcp://" + str(ip_address) + ":" + str(port)'
    timeout: '10'
  states: {}

connections:
- [adsb_decoder_0_0, decoded, blocks_message_debug_0, store]
- [adsb_decoder_0_0, decoded, zeromq_pub_msg_sink_0_0, in]
- [adsb_demod_0, '0', blocks_null_sink_0, '0']
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [adsb_framer_1, '0', qtgui_time_sink_x_1_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
