options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: waterfall_bladerf2
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    orient: Qt.Horizontal
    start: '50'
    step: '.1'
    stop: '3800'
    value: '2412'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '40'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 5e6, 10e6, 20e6]'
    type: real
    value: 1e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=" + str(serial)'
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: rx_frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: rx_gain
    iq_balance_mode0: '1'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,6,4
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: '"0"'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
