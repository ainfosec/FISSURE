options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: j2497_mod
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: tx_freq
    orient: Qt.Horizontal
    start: 100e3
    step: 100e3
    stop: 150e6
    value: 125e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '20'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10000000'
    type: complex
  states: {state: disabled}
- name: j2497_encoder_0
  id: j2497_encoder
  parameters:
    data: '00'
    filepath_data: /home/user/chirp_test_8MSps.iq
    filepath_preamble: /home/user/chirp_test_8MSps.iq
    interval: '1'
    mid: 0A
    sample_rate: samp_rate
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '.125'
    type: complex
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: tx_freq
    gain0: '10'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    size: '100000'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [j2497_encoder_0, '0', limesdr_sink_0, '0']
- [j2497_encoder_0, '0', mmse_resampler_xx_0, '0']
- [j2497_encoder_0, '0', osmosdr_sink_0, '0']
- [j2497_encoder_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [j2497_encoder_0, '0', uhd_usrp_sink_0, '0']
- [mmse_resampler_xx_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
