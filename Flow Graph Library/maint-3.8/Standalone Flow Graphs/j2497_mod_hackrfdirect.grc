options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: j2497_mod_hackrfdirect
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '47'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-samp_rate/4.'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: samp_rate / 4.
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/4. + 50.e3, -samp_rate/4.+450.e3, 100e3)
    type: ccc
  states: {}
- name: j2497_encoder_0
  id: j2497_encoder
  parameters:
    data: '00'
    filepath_data: /home/user/chirp_test_8MSps.iq
    filepath_preamble: /home/user/chirp_test_8MSps.iq
    interval: '1'
    mid: 0A
    sample_rate: samp_rate
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: samp_rate / 4.
    gain0: '14'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    size: '100000'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', osmosdr_sink_0, '0']
- [j2497_encoder_0, '0', blocks_multiply_xx_0, '0']
- [j2497_encoder_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [j2497_encoder_0, '0', qtgui_time_sink_x_0_0_0_1, '0']

metadata:
  file_format: 1
