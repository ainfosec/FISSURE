options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: gsm_uplink_downlink
    output_language: python
    title: Adapted from gr-gsm Livemon
  states: {}

blocks:
- name: fc_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '100'
    orient: Qt.Horizontal
    start: 800e6
    step: 2e5
    stop: 1990e6
    value: fc
  states: {}
- name: fc_slider_uplink
  id: variable_qtgui_range
  parameters:
    label: Uplink Frequency
    min_len: '100'
    orient: Qt.Horizontal
    start: 800e6
    step: 2e5
    stop: 1990e6
    value: 1850.2e6
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: Gain
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '40'
    value: gain
    widget: counter
  states: {}
- name: ppm_slider
  id: variable_qtgui_range
  parameters:
    label: PPM Offset
    min_len: '100'
    orient: Qt.Horizontal
    start: '-150'
    step: '0.1'
    stop: '150'
    value: ppm
    widget: counter
  states: {}
- name: args
  id: parameter
  parameters:
    label: Device Arguments
    value: '""'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '300000000'
    type: complex
  states: {state: disabled}
- name: blocks_head_0_1
  id: blocks_head
  parameters:
    num_items: '300000000'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*pi*shiftoff/samp_rate'
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*pi*shiftoff/samp_rate'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2000000'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: '2000000'
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: serverport
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_0_1_1
  id: blocks_socket_pdu
  parameters:
    host: collector
    mtu: '1500'
    port: collectorport
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_1_1_0
  id: blocks_socket_pdu
  parameters:
    host: collector
    mtu: '1500'
    port: collectorport
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: '100000'
    type: complex
    vector: (0.5,0.5,0.5)
  states: {state: disabled}
- name: collector
  id: parameter
  parameters:
    label: IP or DNS name of collector point
    type: str
    value: '"localhost"'
  states: {}
- name: collectorport
  id: parameter
  parameters:
    label: UDP port number of collector
    type: str
    value: '4729'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: GSM channel's central frequency
    short_id: f
    type: eng_float
    value: 1930.2e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: eng_float
    value: '32'
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0_0
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0_0_0
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '4'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0_1
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '2'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0_1_0
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '5'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0_1_0_0
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '6'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0_1_0_0_0
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '7'
  states: {}
- name: gsm_bcch_ccch_sdcch4_demapper_0_2
  id: gsm_bcch_ccch_sdcch4_demapper
  parameters:
    timeslot_nr: '3'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc_slider-shiftoff
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_clock_offset_control_0_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc_slider_uplink-shiftoff
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_1
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_1_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_1_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_1_0_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_2
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_1
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_1_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_1_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_1_1
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_1_1_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_1_2
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_1_3
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[]'
  states: {state: disabled}
- name: gsm_input_0
  id: gsm_input
  parameters:
    fc: fc_slider-shiftoff
    ppm: ppm-int(ppm)
    samp_rate_in: samp_rate
  states: {}
- name: gsm_input_0_0
  id: gsm_input
  parameters:
    fc: fc_slider-shiftoff
    ppm: ppm-int(ppm)
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_1
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {state: disabled}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[arfcn.downlink2arfcn(fc)]'
    osr: osr
  states: {state: disabled}
- name: gsm_receiver_with_uplink_0
  id: gsm_receiver_with_uplink
  parameters:
    osr: '4'
    tseq_nums: '[2]'
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_sdcch8_demapper_0_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: gsm_sdcch8_demapper_0_0_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '2'
  states: {}
- name: gsm_sdcch8_demapper_0_0_0_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '6'
  states: {}
- name: gsm_sdcch8_demapper_0_0_1
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '3'
  states: {}
- name: gsm_sdcch8_demapper_0_0_1_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '7'
  states: {}
- name: gsm_sdcch8_demapper_0_0_2
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '4'
  states: {}
- name: gsm_sdcch8_demapper_0_0_3
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '5'
  states: {}
- name: gsm_uplink_downlink_splitter_0
  id: gsm_uplink_downlink_splitter
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from grgsm import arfcn
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OverSampling Ratio
    type: intx
    value: '4'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: ppm
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc_slider
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: '"Uplink"'
    size: '2000000'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: '"Downlink"'
    size: '2000000'
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '20'
    bw0: 250e3+abs(shiftoff)
    corr0: ppm_slider
    dc_offset_mode0: '2'
    freq0: fc_slider-shiftoff
    gain0: gain_slider
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: '2000000'
  states: {}
- name: serverport
  id: parameter
  parameters:
    label: UDP server listening port
    type: str
    value: '4729'
  states: {}
- name: shiftoff
  id: parameter
  parameters:
    label: Frequency Shiftoff
    short_id: o
    type: eng_float
    value: 400e3
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc_slider-shiftoff
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"addr=" + "192.168.40.2"'
    dev_args: '""'
    gain0: gain_slider
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"B:0"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc_slider_uplink-shiftoff
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"addr=" + "192.168.140.2"'
    dev_args: '""'
    gain0: '20'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"B:0"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc_slider-shiftoff
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '""'
    gain0: '60'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_rotator_cc_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_null_source_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_null_source_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_rotator_cc_0, '0', gsm_input_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0_0, '0', gsm_input_0_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_skiphead_0_1, '0', blocks_head_0_1, '0']
- [blocks_socket_pdu_0_0_0, pdus, gsm_message_printer_1, msgs]
- [blocks_vector_insert_x_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_vector_insert_x_0, '0', blocks_rotator_cc_0_0, '0']
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0, bursts, gsm_control_channels_decoder_0_0_0, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0_0, bursts, gsm_control_channels_decoder_0_0_0_0, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0_0_0, bursts, gsm_control_channels_decoder_0_0_0_0_0, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0_1, bursts, gsm_control_channels_decoder_0_0_0_1, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0_1_0, bursts, gsm_control_channels_decoder_0_0_0_1_0, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0_1_0_0, bursts, gsm_control_channels_decoder_0_0_0_1_0_0, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0_1_0_0_0, bursts, gsm_control_channels_decoder_0_0_0_1_0_0_0, bursts]
- [gsm_bcch_ccch_sdcch4_demapper_0_2, bursts, gsm_control_channels_decoder_0_0_0_2, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_clock_offset_control_0_0, ctrl, gsm_input_0_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0_0_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0_1, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0_1_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0_1_0_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0_1_0_0_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_0_2, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_1, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_1_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_1_0_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_1_1, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_1_1_0, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_1_2, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_control_channels_decoder_0_0_1_3, msgs, gsm_uplink_downlink_splitter_0, in]
- [gsm_decryption_0, bursts, gsm_control_channels_decoder_0_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_input_0, '0', gsm_receiver_with_uplink_0, '0']
- [gsm_input_0_0, '0', gsm_receiver_with_uplink_0, '1']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0_0, measurements]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0_0_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0_1, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0_1_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0_1_0_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0_1_0_0_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_bcch_ccch_sdcch4_demapper_0_2, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0_0_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0_0_0_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0_0_1, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0_0_1_0, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0_0_2, bursts]
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0_0_3, bursts]
- [gsm_receiver_with_uplink_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_receiver_with_uplink_0, measurements, gsm_clock_offset_control_0_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_control_channels_decoder_0_0, bursts]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0, bursts]
- [gsm_sdcch8_demapper_0_0, bursts, gsm_control_channels_decoder_0_0_1, bursts]
- [gsm_sdcch8_demapper_0_0_0, bursts, gsm_control_channels_decoder_0_0_1_0, bursts]
- [gsm_sdcch8_demapper_0_0_0_0, bursts, gsm_control_channels_decoder_0_0_1_0_0, bursts]
- [gsm_sdcch8_demapper_0_0_1, bursts, gsm_control_channels_decoder_0_0_1_1, bursts]
- [gsm_sdcch8_demapper_0_0_1_0, bursts, gsm_control_channels_decoder_0_0_1_1_0, bursts]
- [gsm_sdcch8_demapper_0_0_2, bursts, gsm_control_channels_decoder_0_0_1_2, bursts]
- [gsm_sdcch8_demapper_0_0_3, bursts, gsm_control_channels_decoder_0_0_1_3, bursts]
- [gsm_uplink_downlink_splitter_0, downlink, blocks_socket_pdu_0_1_1, pdus]
- [gsm_uplink_downlink_splitter_0, uplink, blocks_socket_pdu_0_1_1_0, pdus]
- [rtlsdr_source_0, '0', blocks_keep_one_in_n_0_0, '0']
- [rtlsdr_source_0, '0', blocks_rotator_cc_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_rotator_cc_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_keep_one_in_n_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_rotator_cc_0_0, '0']
- [uhd_usrp_source_0_0_1, '0', blocks_keep_one_in_n_0_0, '0']
- [uhd_usrp_source_0_0_1, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
