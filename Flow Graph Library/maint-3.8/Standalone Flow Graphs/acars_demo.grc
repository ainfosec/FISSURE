options:
  parameters:
    generate_options: qt_gui
    id: acars_demo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: rf_freq
  id: variable_qtgui_chooser
  parameters:
    label0: Europe
    label1: Japan
    label2: worlwide
    num_opts: '3'
    option1: '131.450'
    option2: '131.550'
    type: real
    value: '131.550'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*24
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/N/2
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/N/2
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: acars_acars_0
  id: acars_acars
  parameters:
    filename: /tmp/log1
    saveall: 'False'
    threshold: '3'
  states: {}
- name: acars_acars_0_0
  id: acars_acars
  parameters:
    filename: /tmp/log2
    saveall: 'False'
    threshold: '3'
  states: {state: disabled}
- name: acars_acars_0_0_0
  id: acars_acars
  parameters:
    filename: /tmp/log3
    saveall: 'False'
    threshold: '3'
  states: {state: disabled}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {state: disabled}
- name: analog_am_demod_cf_0_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {state: disabled}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '65e-3'
    min_freq: '-65e-3'
    w: '50e-3'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0
    samp_rate: int(samp_rate/24)
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/sdr/gr-acars-code/3.8ng/examples/gr-acars_1.152M_2.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    decim: N
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100000'
    decim: N
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/N/2
    decim: N
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/N/2
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 131.725e6
    gain0: '49'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: rf_freq*1e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '75'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', acars_acars_0, '0']
- [analog_am_demod_cf_0, '0', audio_sink_0, '0']
- [analog_am_demod_cf_0_0, '0', acars_acars_0_0_0, '0']
- [analog_am_demod_cf_0_0_0, '0', acars_acars_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_am_demod_cf_0_0, '0']
- [low_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_0, '0', analog_pll_carriertracking_cc_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
