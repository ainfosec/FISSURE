options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: x10_tx_rx
    output_language: python
  states: {}

blocks:
- name: address_code
  id: variable
  parameters:
    value: '"0x60"'
  states: {}
- name: data_code
  id: variable
  parameters:
    value: '"0x00"'
  states: {}
- name: press_duration
  id: variable
  parameters:
    value: '4'
  states: {}
- name: press_repetition_interval
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: rx_usrp_frequency
  id: variable
  parameters:
    value: 310.8e6
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["address_code","data_code"]'
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: X10_message_generator_0
  id: X10_message_generator
  parameters:
    address_code: address_code
    data_code: data_code
    press_duration: press_duration
    press_repetition_interval: press_repetition_interval
    sample_rate: sample_rate
  states: {}
- name: X10_x10_decoder_1
  id: X10_x10_decoder
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '125'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1000'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '.05'
    init: '0'
    low: '.05'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '111111111111111111111111111111111111111100000000000000000000'
    tagname: Start
    threshold: '0'
    type: byte
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[0.125]*8'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '10000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '10000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: 310.7e6
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_usrp_frequency
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_usrp_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [X10_message_generator_0, '0', blocks_multiply_const_vxx_0, '0']
- [X10_x10_decoder_1, bytes, blocks_message_debug_0, print]
- [X10_x10_decoder_1, out, blocks_message_debug_0, print]
- [blocks_char_to_float_0, '0', X10_x10_decoder_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_null_source_0, '0', X10_message_generator_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
