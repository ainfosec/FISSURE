options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: FM_Radio_Capture
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay_length
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: frequency_offset
  id: variable
  parameters:
    value: 0.3e6
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Records a fixed amount of FM data to a file and plays it back once on another frequency."'
  states: {}
- name: recording_length
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: repetitions
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 102.5e6
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"B:0"'
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 108e6
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"B:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_offset
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '480000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay_length)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(recording_length)
    type: float
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: (int(recording_length)+int(delay_length))*(int(repetitions))
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '10'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: 25e3
    win: firdes.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 48000/sample_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_frequency+frequency_offset
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: rx_usrp_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_delay_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_head_1, '0']
- [blocks_head_0, '0', blocks_delay_0, '0']
- [blocks_head_1, '0', mmse_resampler_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_head_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [mmse_resampler_xx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
