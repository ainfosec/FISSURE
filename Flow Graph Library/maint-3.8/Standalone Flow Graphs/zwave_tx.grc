options:
  parameters:
    generate_options: qt_gui
    id: zwave_tx
    output_language: python
    title: zwave_tx
  states: {}

blocks:
- name: command
  id: variable
  parameters:
    value: '"0163"'
  states: {state: disabled}
- name: command_class
  id: variable
  parameters:
    value: '"26"'
  states: {state: disabled}
- name: configuration
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: destination_node_id
  id: variable
  parameters:
    value: '"02"'
  states: {}
- name: frame_control
  id: variable
  parameters:
    value: '"4107"'
  states: {state: disabled}
- name: home_id
  id: variable
  parameters:
    value: '"fa1c0b48"'
  states: {}
- name: msg_length
  id: variable
  parameters:
    value: '24'
  states: {}
- name: repetition_interval
  id: variable
  parameters:
    value: '0.15'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: source_node_id
  id: variable
  parameters:
    value: '"01"'
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["home_id","source_node_id","frame_control","destination_node_id","command_class","command"]'
  states: {state: disabled}
- name: tx_freq
  id: variable
  parameters:
    value: 916e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sample_rate/(2*math.pi*80000/8.0)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: (10*8*(26+msg_length+4))-24
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 2*10*8*(26+msg_length+4)
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 10*8*(26+msg_length+4)
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.65'
    samples_per_symbol: '10'
    sensitivity: '0.25'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '20000'
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '20000'
    srate: '1'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zwave_poore_message_generator_pdu_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: 05050000010002ff03000400
    command_class: '33'
    comment: red
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: 410d
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: 050500000100020003ff0400
    command_class: '33'
    comment: green
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: '4108'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: 0505000001000240039c0400
    command_class: '33'
    comment: color list
    configuration: '2'
    destination_node_id: destination_node_id
    frame_control: '4108'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '0100'
    command_class: '26'
    comment: 'off'
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: '4108'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '0163'
    command_class: '26'
    comment: 'on'
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: '4107'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: 0505000001000200030004ff
    command_class: '33'
    comment: blue
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: '4108'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: 0505000001000240039c0400
    command_class: '33'
    comment: random color
    configuration: '3'
    destination_node_id: destination_node_id
    frame_control: '4108'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_delay_1, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_head_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_head_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', uhd_usrp_sink_0, '0']
- [blocks_tag_gate_0, '0', blocks_delay_0, '0']
- [blocks_tag_gate_0, '0', blocks_delay_1, '0']
- [digital_gfsk_mod_0, '0', blocks_tag_gate_0, '0']
- [zwave_poore_message_generator_pdu_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
