<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>DECT_GFSK_USRPX310_Simple_Replay</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_address</value></param>
<param><key>value</key><value>"192.168.40.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>notes</value></param>
<param><key>value</key><value>"Relays a DECT signal to another frequency."</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1921.536e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1923.264e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq_3</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1924.992e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq_4</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1926.720e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq_5</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1928.448e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>value</key><value>1928.448e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_usrp_antenna</value></param>
<param><key>value</key><value>"RX2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_usrp_channel</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_usrp_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>squelch_value</value></param>
<param><key>value</key><value>-23</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>value</key><value>1921.536e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_antenna</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_channel</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>100</value></param>
<param><key>threshold</key><value>squelch_value</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>tx_usrp_antenna</value></param>
<param><key>center_freq0</key><value>tx_frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_usrp_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=" + ip_address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>tx_usrp_channel</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>rx_usrp_antenna</value></param>
<param><key>center_freq0</key><value>rx_frequency</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_usrp_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=" + ip_address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_usrp_channel</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
