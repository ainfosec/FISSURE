options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: DECT_GFSK_USRPX310_Wireshark
    output_language: python
  states: {}

blocks:
- name: baseband_sampling_rate
  id: variable
  parameters:
    value: '3125000'
  states: {}
- name: dect_channel_bandwidth
  id: variable
  parameters:
    value: 1.728e6
  states: {}
- name: dect_occupied_bandwidth
  id: variable
  parameters:
    value: '1382400'
  states: {}
- name: dect_symbol_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Captures DECT signals and pipes the messages to Wireshark."'
  states: {}
- name: resampler_filter_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 3*baseband_sampling_rate, dect_occupied_bandwidth/2, (dect_channel_bandwidth - dect_occupied_bandwidth)/2, 30)
  states: {state: disabled}
- name: rx_freq
  id: variable_qtgui_chooser
  parameters:
    label: Carrier Number
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8", "9", "DECT1","DECT2","DECT3","DECT4","DECT5"]'
    num_opts: '0'
    options: '[1897344000, 1881792000, 1883520000, 1885248000, 1886876000, 1888704000, 1890432000, 1892160000, 1893888000, 1895616000, 1921.536e6, 1923.264e6, 1924.992e6, 1926.720e6, 1928.448e6]'
    type: real
    value: '1897344000'
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: 1924.992e6
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: 1923.264e6
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: 1926.720e6
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: 1928.448e6
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: 1928.448e6
  states: {state: disabled}
- name: rx_freq
  id: variable
  parameters:
    value: 1921.536e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: ainfosec_UDP_to_Wireshark_0
  id: ainfosec_UDP_to_Wireshark
  parameters:
    comment: pcap_fifo block needs to be recreated
    port: '50000'
  states: {}
- name: ainfosec_pcap_fifo_0
  id: ainfosec_pcap_fifo
  parameters:
    port: '50000'
  states: {state: disabled}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '384'
    n: '388'
    offset: '0'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: 11, 48
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '59'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0,0,0,0,0,170,170,170,233,138)
  states: {}
- name: dect2_packet_receiver_0
  id: dect2_packet_receiver
  parameters: {}
  states: {}
- name: dect2_phase_diff_0
  id: dect2_phase_diff
  parameters: {}
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: (3.0*baseband_sampling_rate/2.0)/dect_symbol_rate/4.0
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '3'
    taps: firdes.low_pass_2(1, 3*baseband_sampling_rate, dect_occupied_bandwidth/2, (dect_channel_bandwidth - dect_occupied_bandwidth)/2, 30)
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '"addr=" + ip_address'
    gain0: rx_gain
    samp_rate: baseband_sampling_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_keep_m_in_n_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_mux_0, '1']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_stream_to_tagged_stream_1, '0', ainfosec_UDP_to_Wireshark_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', ainfosec_pcap_fifo_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [dect2_packet_receiver_0, '0', blocks_keep_m_in_n_0, '0']
- [dect2_phase_diff_0, '0', dect2_packet_receiver_0, '0']
- [mmse_resampler_xx_0, '0', dect2_phase_diff_0, '0']
- [rational_resampler_xxx_0, '0', mmse_resampler_xx_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
