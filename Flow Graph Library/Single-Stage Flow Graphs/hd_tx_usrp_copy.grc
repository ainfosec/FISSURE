options:
  parameters:
    generate_options: no_gui
    id: hd_tx_usrp_copy
    output_language: python
    run_options: run
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 90.5e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate * 4
    tau: '75e-6'
  states: {}
- name: artist
  id: parameter
  parameters:
    type: str
    value: '"Test Artist"'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(audio_rate * 3.5)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2160'
    n: '4096'
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.001'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi / 2 * i / 112) for i in range(112)] + [1] * (2048-112) + [math.cos(math.pi / 2 * i / 112) for i in range(112)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: wav1_filepath
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: wav2_filepath
    repeat: 'True'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: str
    value: '"90.5e6"'
  states: {}
- name: gain
  id: parameter
  parameters:
    type: str
    value: '"70"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '0.1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: firdes.WIN_HAMMING
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '64000'
    channels: '2'
  states: {}
- name: nrsc5_l1_fm_encoder_mp1_0
  id: nrsc5_l1_fm_encoder_mp1
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    first_prog: '0'
    num_progs: '1'
    size: '146176'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: artist
    prog_num: '0'
    title: title
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    short_name: ABCD
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    fbw: '0.2'
    interp: '50'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    fbw: '0.2'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '49'
    fbw: '0.2'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '243'
    fbw: '0.2'
    interp: '256'
    taps: ''
    type: ccc
  states: {}
- name: title
  id: parameter
  parameters:
    type: str
    value: '"Test Title"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: float(frequency)
    clock_rate: '0.0'
    gain0: float(gain)
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    stream_args: peak=0.003906
    sync: sync
    type: fc32
  states: {}
- name: wav1_filepath
  id: parameter
  parameters:
    type: str
    value: '"/home/use2r/FISSURE/Flow Graph Library/Single-Stage Flow Graphs/Attack Files/sample.wav"'
  states: {}
- name: wav2_filepath
  id: parameter
  parameters:
    type: str
    value: '"/home/u2ser/FISSURE/Flow Graph Library/Single-Stage Flow Graphs/Attack Files/sample_mono.wav"'
  states: {}

connections:
- [analog_wfm_tx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_delay_0, '0', analog_wfm_tx_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_wavfile_source_0, '0', nrsc5_hdc_encoder_0, '0']
- [blocks_wavfile_source_0, '1', nrsc5_hdc_encoder_0, '1']
- [blocks_wavfile_source_1, '0', blocks_delay_0, '0']
- [fft_vxx_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_l1_fm_encoder_mp1_0, '0', fft_vxx_0, '0']
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '0']
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '1']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
