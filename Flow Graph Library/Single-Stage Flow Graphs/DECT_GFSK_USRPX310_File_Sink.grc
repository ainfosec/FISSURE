options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: DECT_GFSK_USRPX310_File_Sink
    output_language: python
  states: {}

blocks:
- name: dect_channel_bandwidth
  id: variable
  parameters:
    value: 1.728e6
  states: {}
- name: dect_occupied_bandwidth
  id: variable
  parameters:
    value: dect_symbol_rate  * 1.03
  states: {}
- name: dect_symbol_rate
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '"~/FISSURE/Attack Recordings/DECT_Data"'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_default(388,"packet_len","packet_num",1)
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Records a DECT payload to a file."'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '384'
  states: {}
- name: recording_length
  id: variable
  parameters:
    value: 388*2
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 1928.448e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1921.536e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1926.720e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1924.992e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1923.264e6
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 3.456e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.5'
    gate: 'True'
    ramp: '100'
    threshold: '-42'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: byte
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: recording_length
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010101010101110100110001010'
    tagname: '"go"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(sample_rate/dect_symbol_rate)
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '388'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"sandwich"'
    output_symbols: 'False'
    samp_rate: int(sample_rate)
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"go"'
    type: byte
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_frequency
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"addr="+ip_address'
    dev_args: '""'
    gain0: rx_usrp_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', digital_gmsk_demod_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0, '0']
- [blocks_null_source_0, '0', digital_header_payload_demux_0, '1']
- [digital_correlate_access_code_tag_xx_0, '0', digital_header_payload_demux_0, '0']
- [digital_gmsk_demod_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_header_payload_demux_0, '0', blocks_head_0_0, '0']
- [digital_header_payload_demux_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_null_sink_0, '0']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [uhd_usrp_source_0, '0', digital_gmsk_demod_0, '0']

metadata:
  file_format: 1
