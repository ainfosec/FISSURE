options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Mode_S_PPM_USRPB205mini_stdout
    output_language: python
    run_options: run
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Prints ADSB data to stdout."'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    check_parity: 'True'
    output_type: csv
  states: {}
- name: adsb_framer_0
  id: adsb_framer
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/adsb.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.1'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1010000101000000'
    tagname: adsb_preamble
    threshold: '0'
    type: byte
  states: {}
- name: gsm_message_file_sink_0
  id: gsm_message_file_sink
  parameters:
    comment: gr-gsm
    filename: /dev/stdout
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: serial
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: channel
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [adsb_decoder_0, out, blocks_message_debug_0, print]
- [adsb_decoder_0, out, gsm_message_file_sink_0, in]
- [adsb_framer_0, out, adsb_decoder_0, in]
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', adsb_framer_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
