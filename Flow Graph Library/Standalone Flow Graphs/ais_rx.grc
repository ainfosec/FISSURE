options:
  parameters:
    author: Nick Foster
    generate_options: no_gui
    id: ais_rx
    output_language: python
    title: Soapy AIS receiver
  states: {}

blocks:
- name: ais_rx_core_0
  id: ais_rx_core
  parameters:
    bb_sps: '4'
    bt: '0.4'
    loopbw: ted_bw
    samp_rate: samp_rate
    threshold: threshold
  states: {}
- name: ais_rx_core_0_0
  id: ais_rx_core
  parameters:
    bb_sps: '4'
    bt: '0.4'
    loopbw: ted_bw
    samp_rate: samp_rate
    threshold: threshold
  states: {}
- name: ant
  id: parameter
  parameters:
    label: Antenna
    type: str
    value: TX/RX
  states: {}
- name: args
  id: parameter
  parameters:
    label: Device args
    type: str
    value: '""'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: A channel
    phase_inc: 2*math.pi*(-25e3/samp_rate)
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: B channel
    phase_inc: 2*math.pi*(25e3/samp_rate)
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: intx
    value: '70'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pdu_to_nmea_0
  id: pdu_to_nmea
  parameters:
    designator: A
  states: {}
- name: pdu_to_nmea_0_0
  id: pdu_to_nmea
  parameters:
    designator: B
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 200e3
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 162e6
    gain: '65'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    ant0: ant
    balance0: '0'
    bw0: 200e3
    center_freq0: 162e6
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: uhd
    overall_gain0: gain
    samp_rate: samp_rate
    stream_args: stream_args
    type: fc32
  states: {state: disabled}
- name: stream_args
  id: parameter
  parameters:
    label: Stream args
    type: str
    value: '""'
  states: {}
- name: ted_bw
  id: parameter
  parameters:
    label: TED bandwidth
    type: eng_float
    value: '0.033'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Correlator threshold
    type: eng_float
    value: '0.83'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ant
    center_freq0: 162e6
    dev_args: '"args"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ais_rx_core_0, out, pdu_to_nmea_0, print]
- [ais_rx_core_0_0, out, pdu_to_nmea_0_0, print]
- [blocks_rotator_cc_0, '0', ais_rx_core_0, '0']
- [blocks_rotator_cc_0_0, '0', ais_rx_core_0_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_rotator_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_rotator_cc_0_0, '0']
- [soapy_source_0, '0', blocks_rotator_cc_0, '0']
- [soapy_source_0, '0', blocks_rotator_cc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
