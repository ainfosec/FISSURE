options:
  parameters:
    generate_options: no_gui
    id: ais_rx_demod
    output_language: python
    run_options: run
    title: ais_rx_demod
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: coeffs
  id: variable
  parameters:
    value: filter.firdes.low_pass(1, samp_rate, 11000,1000)
  states: {}
- name: demod_clockrec_gain
  id: variable
  parameters:
    value: '0.04'
  states: {}
- name: demod_fftlen
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: demod_omega_lim
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: demod_samp_rate
  id: variable
  parameters:
    value: bit_rate * samples_symbol
  states: {}
- name: demod_sps
  id: variable
  parameters:
    value: (samp_rate/filter_decimation)/bit_rate
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: int(samp_rate/(bit_rate*samples_symbol))
  states: {}
- name: mod_vector
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: digital.gmsk_mod(demod_sps, 0.4)
    taps: '[1]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[1,1,0,0]*7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samples_symbol
  id: variable
  parameters:
    value: '5'
  states: {}
- name: ais_invert_0
  id: ais_invert
  parameters: {}
  states: {}
- name: ais_invert_0_0
  id: ais_invert
  parameters: {}
  states: {}
- name: ais_pdu_to_nmea_0_0
  id: ais_pdu_to_nmea
  parameters:
    designator: A
  states: {}
- name: ais_pdu_to_nmea_0_0_0
  id: ais_pdu_to_nmea
  parameters:
    designator: B
  states: {}
- name: ais_square_and_fft_sync_0
  id: ais_square_and_fft_sync
  parameters:
    fftlen: '1024'
    rate: demod_samp_rate
    sps: bit_rate
  states: {}
- name: ais_square_and_fft_sync_0_0
  id: ais_square_and_fft_sync
  parameters:
    fftlen: '1024'
    rate: demod_samp_rate
    sps: bit_rate
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '512'
    reference: '2'
  states: {}
- name: analog_feedforward_agc_cc_0_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '512'
    reference: '2'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: math.pi / 2
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: math.pi / 2
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: demod_sps
    symbols: mod_vector
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_corr_est_cc_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: demod_sps
    symbols: mod_vector
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_hdlc_deframer_bp_0_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: digital_hdlc_deframer_bp_0_0_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: digital_msk_timing_recovery_cc_0
  id: digital_msk_timing_recovery_cc
  parameters:
    gain: demod_clockrec_gain
    limit: demod_omega_lim
    osps: '1'
    sps: demod_sps
  states: {}
- name: digital_msk_timing_recovery_cc_0_0
  id: digital_msk_timing_recovery_cc
  parameters:
    gain: demod_clockrec_gain
    limit: demod_omega_lim
    osps: '1'
    sps: demod_sps
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-25000'
    decim: filter_decimation
    samp_rate: samp_rate
    taps: coeffs
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '25000'
    decim: filter_decimation
    samp_rate: samp_rate
    taps: coeffs
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,biastee=0
    bb_gain0: '20'
    freq0: '162000000'
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: '162000000'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '80'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ais_invert_0, '0', digital_hdlc_deframer_bp_0_0, '0']
- [ais_invert_0_0, '0', digital_hdlc_deframer_bp_0_0_0, '0']
- [ais_square_and_fft_sync_0, '0', analog_feedforward_agc_cc_0, '0']
- [ais_square_and_fft_sync_0_0, '0', analog_feedforward_agc_cc_0_0, '0']
- [analog_feedforward_agc_cc_0, '0', digital_corr_est_cc_0, '0']
- [analog_feedforward_agc_cc_0_0, '0', digital_corr_est_cc_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_corr_est_cc_0, '0', digital_msk_timing_recovery_cc_0, '0']
- [digital_corr_est_cc_0_0, '0', digital_msk_timing_recovery_cc_0_0, '0']
- [digital_diff_decoder_bb_0, '0', ais_invert_0, '0']
- [digital_diff_decoder_bb_0_0, '0', ais_invert_0_0, '0']
- [digital_hdlc_deframer_bp_0_0, out, ais_pdu_to_nmea_0_0, print]
- [digital_hdlc_deframer_bp_0_0_0, out, ais_pdu_to_nmea_0_0_0, print]
- [digital_msk_timing_recovery_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_msk_timing_recovery_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', ais_square_and_fft_sync_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', ais_square_and_fft_sync_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
