options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: channel_select
  id: variable
  parameters:
    value: '2'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '326531'
  states: {}
- name: AISTX_Build_Frame_0
  id: AISTX_Build_Frame
  parameters:
    enable_NRZI: 'False'
    repeat: 'True'
    sentence: sentence0
  states: {}
- name: AISTX_Build_Frame_1
  id: AISTX_Build_Frame
  parameters:
    enable_NRZI: 'False'
    repeat: 'True'
    sentence: sentence1
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-25000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '25000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.45'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.45'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel_select
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: digital_gmsk_mod_0_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=24993a63
    bb_gain0: '20'
    freq0: 162e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: samp_rate
    type: complex
  states: {}
- name: sentence0
  id: parameter
  parameters:
    label: Sentence 0
    short_id: s
    type: str
    value: '010101000001110101101111001101000101011100000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010110111111010010100001110110111001011110111000000000000000000000000000000000000011110000000000000000000'
  states: {}
- name: sentence1
  id: parameter
  parameters:
    label: Sentence 1
    short_id: d
    type: str
    value: '000001000011010011111011010111100011101111100000000000010100000000000101100010011111100000011101110100110011010010001101110111101111111111001100000000000000000000000000'
  states: {state: disabled}
- name: sentence1
  id: parameter
  parameters:
    label: Sentence 1
    short_id: d
    type: str
    value: '011000000001101011000010001011111001010001010000100000100101001110000000100101001110000000000110000000001100110000000101001101001110000000001010000001010100111000'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request_t(162000000, 25000)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [AISTX_Build_Frame_0, '0', digital_gmsk_mod_0, '0']
- [AISTX_Build_Frame_1, '0', digital_gmsk_mod_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_selector_0, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_selector_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_selector_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0, '0', uhd_usrp_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_xx_0, '0']
- [digital_gmsk_mod_0_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
