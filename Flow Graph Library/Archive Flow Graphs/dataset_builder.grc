options:
  parameters:
    author: user
    generate_options: no_gui
    id: dataset_builder
    output_language: python
    run_options: run
    title: Dataset Builder
  states: {}

blocks:
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: float(noise)
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: new_filepath
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: float(freq_shift)
    sample_rate: float(sample_rate)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: float(scale)
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: float(phase_rot)
  states: {}
- name: filepath
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: freq_shift
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: new_filepath
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: noise
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: phase_rot
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: scale
  id: parameter
  parameters:
    type: str
    value: '1'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_rotator_cc_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
