<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dataset_builder</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>float(noise)</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>new_filepath</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>filepath</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>float(scale)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>float(phase_rot)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filepath</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_shift</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>float(freq_shift)</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>float(sample_rate)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>new_filepath</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase_rot</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scale</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"1"</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
