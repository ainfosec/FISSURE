<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>rx_usrp_gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_usrp_antenna</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_usrp_channel</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_address</value></param>
<param><key>value</key><value>"192.168.40.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_burst_size</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_burst_size</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>value</key><value>2425.729695e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_type</value></param>
<param><key>value</key><value>"MSK"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_out</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbits_prior</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>address</value></param>
<param><key>value</key><value>"*:5066"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_code</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>"11010011100100011101001110010001"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=" + ip_address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>sd_spec0</key><value>rx_usrp_channel</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>center_freq0</key><value>rx_frequency</value></param>
<param><key>gain0</key><value>rx_usrp_gain</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>rx_usrp_antenna</value></param>
<param><key>bw0</key><value>sample_rate</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>test</value></param>
<param><key>description</key><value>Generic demodulation flow graph for MSK signals.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
