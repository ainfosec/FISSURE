<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>waterfall_usrp_x410</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>value</key><value>2412</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>label</key><value> Freq. (MHz):</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>7200</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rx_usrp_antenna</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>        Antenna</value></param>
<param><key>labels</key><value>["TX/RX", "RX2"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>["TX/RX", "RX2"]</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_usrp_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>label</key><value>              Gain:</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>labels</key><value>["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s", "50 MS/s", "100 MS/s", "200 MS/s", "300 MS/s", "400 MS/s", "500 MS/s"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1e6, 5e6, 10e6, 20e6, 50e6, 100e6, 200e6, 300e6, 400e6, 500e6]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip_address</value></param>
<param><key>label</key><value>ip_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"192.168.140.2"</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,6,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_usrp_channel</value></param>
<param><key>label</key><value>rx_usrp_channel</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>rx_usrp_antenna</value></param>
<param><key>center_freq0</key><value>rx_frequency*1e6</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_usrp_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=" + str(ip_address)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_usrp_channel</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
