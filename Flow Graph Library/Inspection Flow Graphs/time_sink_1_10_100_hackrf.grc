<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>time_sink_1_10_100_hackrf</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>value</key><value>2412</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>label</key><value> Freq. (MHz):</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_hackrf_gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>label</key><value>              Gain:</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>47</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>labels</key><value>["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1e6, 5e6, 10e6, 20e6]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>rx_hackrf_gain</value></param>
<param><key>freq0</key><value>rx_frequency*1e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>"hackrf=" + str(serial)</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>3,0,10,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"1 in 1"</value></param>
<param><key>size</key><value>100000</value></param>
<param><key>srate</key><value>sample_rate</value></param>
<param><key>tr_level</key><value>0.005</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>15,0,10,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"1 in 10"</value></param>
<param><key>size</key><value>100000</value></param>
<param><key>srate</key><value>sample_rate</value></param>
<param><key>tr_level</key><value>0.005</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>26,0,10,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"1 in 100"</value></param>
<param><key>size</key><value>100000</value></param>
<param><key>srate</key><value>sample_rate</value></param>
<param><key>tr_level</key><value>0.005</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>serial</value></param>
<param><key>label</key><value>serial</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
