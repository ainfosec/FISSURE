options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: time_sink_rtl2832u
    output_language: python
  states: {}

blocks:
- name: decimation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: '  Keep 1 in N'
    labels: '["1","10","100","1000"]'
    num_opts: '0'
    options: '[1,10,100,1000]'
    type: int
    value: '1'
  states: {}
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    orient: Qt.Horizontal
    start: '64'
    step: '.1'
    stop: '1700'
    value: '102.5'
  states: {}
- name: rx_rtl_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '40'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["0.5 MS/s", "1 MS/s", "2 MS/s"]'
    num_opts: '0'
    options: '[0.5e6, 1e6, 2e6]'
    type: real
    value: 1e6
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 14,0,10,4
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,10,4
    label1: ''
    label2: ''
    size: '100000'
    srate: sample_rate/decimation
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: rx_rtl_gain
    freq0: rx_frequency*1e6
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
