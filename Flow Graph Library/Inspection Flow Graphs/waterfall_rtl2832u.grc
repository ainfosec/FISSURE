options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: waterfall_rtl2832u
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    outputmsgname: value
    showports: 'False'
    start: '64'
    step: '.1'
    stop: '1700'
    value: '102.5'
  states: {}
- name: rx_rtl_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '47'
    value: '40'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["0.25 MS/s", "1.024 MS/s", "1.536 MS/s", "1.792 MS/s", "1.92 MS/s", "2.048 MS/s", "2.16 MS/s", "2.56 MS/s", "2.88 MS/s", "3.2 MS/s"]'
    num_opts: '0'
    options: '[0.25e6,1.024e6, 1.536e6, 1.792e6, 1.92e6, 2.048e6, 2.16e6, 2.56e6, 2.88e6, 3.2e6]'
    type: real
    value: 2.048e6
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,6,4
    showports: 'True'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rx_frequency*1e6
    gain: rx_rtl_gain
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
