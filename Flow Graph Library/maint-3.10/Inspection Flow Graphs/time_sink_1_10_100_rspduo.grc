options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: time_sink_1_10_100_rspduo
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    start: '0.001'
    step: '.1'
    stop: '2000'
    value: '102.5'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    start: '0'
    step: '1'
    stop: '59'
    value: '0'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "2 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 2e6, 5e6, 10e6, 20e6]'
    type: real
    value: 2e6
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,10,4
    label1: ''
    label2: ''
    name: '"1 in 1"'
    size: '100000'
    srate: sample_rate
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 15,0,10,4
    label1: ''
    label2: ''
    name: '"1 in 10"'
    size: '100000'
    srate: sample_rate
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 26,0,10,4
    label1: ''
    label2: ''
    name: '"1 in 100"'
    size: '100000'
    srate: sample_rate
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    center_freq: float(rx_frequency)*1e6
    center_freq0: '0'
    center_freq1: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: 59-float(rx_gain)
    if_gRdB0: '40'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gRLNA0: '0'
    rf_gRLNA1: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_gRdB0: '0'
    rf_gRdB1: '0'
    rf_notch_filter: 'False'
    rsp_selector: str(serial)
    rspduo_mode: Single Tuner
    sample_rate: float(sample_rate)
    sample_rate_non_single_tuner: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    synchronous_updates: 'False'
  states: {}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: '0'
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [sdrplay3_rspduo_0, '0', blocks_keep_one_in_n_0, '0']
- [sdrplay3_rspduo_0, '0', blocks_keep_one_in_n_0_0, '0']
- [sdrplay3_rspduo_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
