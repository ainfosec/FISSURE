options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: signal_envelope
    output_language: python
  states: {}

blocks:
- name: decimation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: '  Keep 1 in N'
    labels: '["1","10","100","1000"]'
    num_opts: '0'
    options: '[1,10,100,1000]'
    type: int
    value: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(sample_rate)
    type: complex
  states: {}
- name: filepath
  id: parameter
  parameters:
    label: filepath
    type: str
    value: ''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,20,4
    label1: ''
    size: '100000'
    srate: float(sample_rate)/decimation
    tr_level: '0.005'
    type: float
    update_time: '0.1'
    ymin: '-.1'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: sample_rate
    type: str
    value: 1e6
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
