options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: waterfall
    output_language: python
  states: {}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(sample_rate)
    type: complex
  states: {}
- name: filepath
  id: parameter
  parameters:
    label: filepath
    type: str
    value: ''
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: float(sample_rate)
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,6,4
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: sample_rate
    type: str
    value: 1e6
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
