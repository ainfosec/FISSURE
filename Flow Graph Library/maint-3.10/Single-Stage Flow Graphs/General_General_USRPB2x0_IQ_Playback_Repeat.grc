options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: General_General_USRPB2x0_IQ_Playback_Repeat
    output_language: python
    run_options: run
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Replays an IQ file on repeat."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 2425.715e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: float(tx_frequency)
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: float(tx_gain)
    len_tag_name: ''
    samp_rate: float(sample_rate)
    sd_spec0: tx_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
