options:
  parameters:
    author: user
    generate_options: no_gui
    id: General_OOK_USRPB210_OOK_Transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: burst_interval_us
  id: variable
  parameters:
    value: '100'
  states: {}
- name: channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: chip0_duration_us
  id: variable
  parameters:
    value: '10'
  states: {}
- name: chip0_pattern
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: chip1_duration_us
  id: variable
  parameters:
    value: '10'
  states: {}
- name: chip1_pattern
  id: variable
  parameters:
    value: '"1"'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 310.4e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Generates custom on-off keying signals with repeating bursts at regular intervals."'
  states: {}
- name: number_of_bursts
  id: variable
  parameters:
    value: '5'
  states: {}
- name: repetition_interval_s
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sequence
  id: variable
  parameters:
    value: '"10101011"'
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["chip0_pattern","chip1_pattern","sequence"]'
  states: {}
- name: ainfosec_ook_generator_0
  id: ainfosec_ook_generator
  parameters:
    burst_interval: float(burst_interval_us)
    chip0_duration: float(chip0_duration_us)
    chip0_pattern: str(chip0_pattern)
    chip1_duration: float(chip1_duration_us)
    chip1_pattern: str(chip1_pattern)
    number_of_bursts: int(number_of_bursts)
    repetition_interval: float(repetition_interval_s)
    sample_rate: float(sample_rate)
    sequence: str(sequence)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(sample_rate)
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '300000'
    srate: float(sample_rate)
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: antenna
    center_freq0: float(frequency)
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: float(gain)
    len_tag_name: ''
    samp_rate: float(sample_rate)
    sd_spec0: channel
    sync: sync
    type: fc32
  states: {}

connections:
- [ainfosec_ook_generator_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', ainfosec_ook_generator_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
