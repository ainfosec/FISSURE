options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: iq_playback_single_plutosdr
    output_language: python
    run_options: run
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.2.1"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '""'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: '2425.715'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '64'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'False'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 89.75 - float(tx_gain)
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(float(tx_frequency)*1e6)
    samplerate: int(float(sample_rate)*1e6)
    uri: '"ip:" + str(ip_address)'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: sample_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
