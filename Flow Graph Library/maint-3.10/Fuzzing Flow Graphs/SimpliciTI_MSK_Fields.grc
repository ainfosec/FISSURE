<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SimpliciTI_MSK_Fields</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0xAA,0xAA,0xAA,0xAA,0xD3,0x91,0xD3,0x91,0x0E,0x78,0x56,0x34,0x12,0xAA,0xAA,0xAA,0xAA,0x20,0x03,0x33,0xAA,0x00,0xFF,0xE4,0x0D</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0xAA,0xAA,0xAA,0xAA,0xD3,0x91,0xD3,0x91,0x0E,0x78,0x56,0x34,0x12,0xAA,0xAA,0xAA,0xAA,0x20,0x03,0x33,0xAA,0x40,0xFF,0x64,0x0B</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_data</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_fields</value></param>
<param><key>value</key><value>"['Temperature LSB','Voltage']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_interval</value></param>
<param><key>value</key><value>"1"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_max</value></param>
<param><key>value</key><value>"['255','255']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_min</value></param>
<param><key>value</key><value>"['0','0']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_packet_type</value></param>
<param><key>value</key><value>"ED-Data"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_protocol</value></param>
<param><key>value</key><value>"SimpliciTI"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_seed</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_type</value></param>
<param><key>value</key><value>"['Random','Sequential']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_address</value></param>
<param><key>value</key><value>"192.168.40.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>library_filepath</value></param>
<param><key>value</key><value>"~/FISSURE/YAML/library_3_10.yaml"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>value</key><value>2425.6e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_antenna</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_usrp_channel</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_mute_xx</key>
<param><key>id</key><value>blocks_mute_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mute</key><value>False</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>digital_gfsk_mod</key>
<param><key>id</key><value>digital_gfsk_mod_0</value></param>
<param><key>bt</key><value>0.5</value></param>
<param><key>samples_per_symbol</key><value>4</value></param>
<param><key>sensitivity</key><value>0.2</value></param>
</block>
<block>
<key>fuzzer_fuzzer</key>
<param><key>id</key><value>fuzzer_fuzzer_0</value></param>
<param><key>fuzzing_data</key><value>fuzzing_data</value></param>
<param><key>fuzzing_fields</key><value>fuzzing_fields</value></param>
<param><key>fuzzing_interval</key><value>fuzzing_interval</value></param>
<param><key>fuzzing_max</key><value>fuzzing_max</value></param>
<param><key>fuzzing_min</key><value>fuzzing_min</value></param>
<param><key>fuzzing_packet_type</key><value>fuzzing_packet_type</value></param>
<param><key>fuzzing_protocol</key><value>fuzzing_protocol</value></param>
<param><key>fuzzing_seed</key><value>fuzzing_seed</value></param>
<param><key>fuzzing_type</key><value>fuzzing_type</value></param>
<param><key>library_filepath</key><value>library_filepath</value></param>
</block>
<block>
<key>fuzzer_packet_insert</key>
<param><key>id</key><value>fuzzer_packet_insert_0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>period</key><value>20</value></param>
<param><key>vector</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>tx_usrp_antenna</value></param>
<param><key>center_freq0</key><value>tx_frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"addr=" + ip_address</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>sd_spec0</key><value>tx_usrp_channel</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_not_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_mute_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_mute_xx_0</sink_block_id><source_key>0</source_key><sink_key>set_mute</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_mute_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0_0</source_block_id><sink_block_id>digital_gfsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>fuzzer_packet_insert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fuzzer_fuzzer_0</source_block_id><sink_block_id>fuzzer_packet_insert_0</sink_block_id><source_key>packet_out</source_key><sink_key>packet_in</sink_key></connection>
<connection><source_block_id>fuzzer_packet_insert_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fuzzer_packet_insert_0</source_block_id><sink_block_id>blocks_mute_xx_0</sink_block_id><source_key>set_mute</source_key><sink_key>set_mute</sink_key></connection>
</flow_graph>
