<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>X10_OOK_LimeSDR_Fields</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>address_code</value></param>
<param><key>value</key><value>"0x60"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_code</value></param>
<param><key>value</key><value>"0x00"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_data</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_fields</value></param>
<param><key>value</key><value>"['Address Code']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_interval</value></param>
<param><key>value</key><value>"5"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_max</value></param>
<param><key>value</key><value>"['65535']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_min</value></param>
<param><key>value</key><value>"['0']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_packet_type</value></param>
<param><key>value</key><value>"Default"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_protocol</value></param>
<param><key>value</key><value>"X10"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_seed</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fuzzing_type</value></param>
<param><key>value</key><value>"['Random']"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>library_filepath</value></param>
<param><key>value</key><value>"~/FISSURE/YAML/library_3_10.yaml"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>string_variables</value></param>
<param><key>value</key><value>["address_code","data_code"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transmit_interval</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_channel</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>value</key><value>310.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>X10_msg_gen_fuzzer</key>
<param><key>id</key><value>X10_msg_gen_fuzzer_0</value></param>
<param><key>address_code</key><value>address_code</value></param>
<param><key>data_code</key><value>data_code</value></param>
<param><key>press_duration</key><value>transmit_interval/2</value></param>
<param><key>press_repetition_interval</key><value>transmit_interval</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.9</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fuzzer_fuzzer</key>
<param><key>id</key><value>fuzzer_fuzzer_0_0</value></param>
<param><key>fuzzing_data</key><value>fuzzing_data</value></param>
<param><key>fuzzing_fields</key><value>fuzzing_fields</value></param>
<param><key>fuzzing_interval</key><value>fuzzing_interval</value></param>
<param><key>fuzzing_max</key><value>fuzzing_max</value></param>
<param><key>fuzzing_min</key><value>fuzzing_min</value></param>
<param><key>fuzzing_packet_type</key><value>fuzzing_packet_type</value></param>
<param><key>fuzzing_protocol</key><value>fuzzing_protocol</value></param>
<param><key>fuzzing_seed</key><value>fuzzing_seed</value></param>
<param><key>fuzzing_type</key><value>fuzzing_type</value></param>
<param><key>library_filepath</key><value>library_filepath</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>int(tx_gain)</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>int(tx_gain)</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>channel_mode</key><value>int(tx_channel)</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>tx_frequency</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<connection><source_block_id>X10_msg_gen_fuzzer_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>X10_msg_gen_fuzzer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fuzzer_fuzzer_0_0</source_block_id><sink_block_id>X10_msg_gen_fuzzer_0</sink_block_id><source_key>packet_out</source_key><sink_key>fuzzer_in</sink_key></connection>
</flow_graph>
