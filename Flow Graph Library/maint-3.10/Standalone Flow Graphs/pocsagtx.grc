options:
  parameters:
    author: cstone@pobox.com
    category: Custom
    description: Example flowgraph for POCSAG transmitter
    generate_options: no_gui
    id: pocsagtx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: max_deviation
  id: variable
  parameters:
    value: '4500.0'
  states: {}
- name: pagerfreq
  id: variable
  parameters:
    value: '158700000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: symrate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2.0 * math.pi * max_deviation / float(symrate)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: capcode
  id: parameter
  parameters:
    type: intx
    value: '425321'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: message
  id: parameter
  parameters:
    type: str
    value: GRAND CENTRAL\x0a\x0aHACKRF THE PLANET
  states: {}
- name: mixalot_pocencode_0
  id: mixalot_pocencode
  parameters:
    baudrate: '512'
    capcode: capcode
    msg: message
    symrate: symrate
    type: '1'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: pagerfreq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '16'
    rrate: float(samp_rate)/float(symrate)
    type: ccf
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [mixalot_pocencode_0, '0', blocks_char_to_float_0, '0']
- [pfb_arb_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
