options:
  parameters:
    author: user
    generate_options: no_gui
    id: strongest
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: short
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samples)*5
    type: complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: float(sample_rate)
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vec_len=8192, peak_detect_file="/tmp/indexes.data", fft_threshold=-80, sample_rate=1000000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32,vec_len)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.peak_detect_file=peak_detect_file
              self.fft_threshold=fft_threshold
              self.vec_len=vec_len
              self.sample_rate=sample_rate
              self.max_value=-100
              self.max_index=-1
              print("Starting Frequency Detection")


          def work(self, input_items,output_items):
              over_threshold = input_items[0][0][np.nonzero(input_items[0][0] > self.fft_threshold)]
              if len(over_threshold) > 0:
                  if over_threshold.max() > self.max_value:
                      self.max_value = over_threshold.max()
                      self.max_index = input_items[0][0].argmax()
                      print("Strongest Freq.: " + str(self.max_value) + ' (dB), ' + str(self.max_index) + ' (bin), ' + str(float(self.max_index/self.vec_len)*self.sample_rate-float(self.sample_rate/2)) + " (Hz)")
                  
                      with open(self.peak_detect_file,'w') as fobj:
                          fobj.write(str(float(self.max_index/self.vec_len)*self.sample_rate-float(self.sample_rate/2)))
              return len(input_items[0])
    fft_threshold: float(fft_threshold)
    peak_detect_file: str(peak_file_location)
    sample_rate: float(sample_rate)
    vec_len: int(fft_size)
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    type: str
    value: '8192'
  states: {}
- name: fft_threshold
  id: parameter
  parameters:
    label: fft_threshold
    type: str
    value: '-80'
  states: {}
- name: filepath
  id: parameter
  parameters:
    label: filepath
    type: str
    value: '"/home/user/Conditioner/Data/tpms/four_tires2.iq"'
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1'
    fft_size: int(fft_size)
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: float(sample_rate)
    shift: 'True'
    type: complex
  states: {}
- name: peak_file_location
  id: parameter
  parameters:
    label: peak_file_location
    type: str
    value: '"/home/user/FISSURE/Flow Graph Library/TSI Flow Graphs/Conditioner/peaks.txt"'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: int(fft_size)
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: sample_rate
  id: parameter
  parameters:
    label: sample_rate
    type: str
    value: '1000000'
  states: {}
- name: samples
  id: parameter
  parameters:
    label: samples
    type: str
    value: '4169300'
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_head_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_head_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [logpwrfft_x_0, '0', epy_block_0, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0_0, '0']

metadata:
  file_format: 1
