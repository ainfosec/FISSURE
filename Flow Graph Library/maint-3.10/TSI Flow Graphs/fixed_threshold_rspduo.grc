options:
  parameters:
    author: user
    generate_options: qt_gui
    id: fixed_threshold_rspduo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: below_zero
  id: variable
  parameters:
    value: '-1000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: full_band_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: in_box_spec_len
  id: variable
  parameters:
    value: int(np.abs(up_line_adj-low_line_adj))
  states: {}
- name: low_bound_vec_bottom_half
  id: variable
  parameters:
    value: (low_line_adj)*(below_zero,)
  states: {}
- name: low_bound_vec_top_half
  id: variable
  parameters:
    value: (fft_size-low_line_adj-1)*(below_zero,)
  states: {}
- name: low_line_adj
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,4
    rangeType: int
    start: '1'
    step: '1'
    stop: '8191'
    value: '1'
  states: {}
- name: rx_antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: '        Antenna'
    labels: '["TX/RX", "RX2"]'
    num_opts: '0'
    options: '["TX/RX", "RX2"]'
    type: string
    value: antenna_default
  states: {state: disabled}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: ' Freq. (MHz):'
    start: '0.001'
    step: '.1'
    stop: '2000'
    value: float(rx_freq_default)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: '              Gain:'
    start: '0'
    step: '1'
    stop: '59'
    value: float(gain_default)
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "2 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 2e6, 5e6, 10e6, 20e6]'
    type: real
    value: float(sample_rate_default)
  states: {}
- name: thresh_adj
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,4
    label: Thresh
    start: '-120'
    step: '1'
    stop: '20'
    value: float(threshold_default)
  states: {}
- name: up_bound_vec_bottom_half
  id: variable
  parameters:
    value: (up_line_adj)*(below_zero,)
  states: {}
- name: up_bound_vec_top_half
  id: variable
  parameters:
    value: (fft_size-up_line_adj-1)*(below_zero,)
  states: {}
- name: up_line_adj
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,4
    rangeType: int
    start: '1'
    step: '1'
    stop: '8191'
    value: '8191'
  states: {}
- name: vec_height
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: ainfosec_msg_str_to_PUB_1
  id: ainfosec_msg_str_to_PUB
  parameters:
    address: '"tcp://127.0.0.1:5060"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.2'
    freq: '-400000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: antenna_default
  id: parameter
  parameters:
    label: antenna_default
    type: str
    value: ''
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: ((below_zero*10),)*(low_line_adj)+(0,)*in_box_spec_len+((below_zero*10),)*(fft_size-up_line_adj)
    type: float
    vlen: fft_size
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
    vlen: fft_size
    vlen_out: fft_size
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (thresh_adj,)*full_band_size
    vlen: fft_size
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: up_bound_vec_bottom_half+(vec_height,)+up_bound_vec_top_half
    vlen: fft_size
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: low_bound_vec_bottom_half+(vec_height,)+low_bound_vec_top_half
    vlen: fft_size
  states: {}
- name: channel_default
  id: parameter
  parameters:
    label: channel_default
    type: str
    value: ''
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt
      import zmq

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vec_len=8192, sample_rate=1000000, rx_freq_mhz=2412):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32,vec_len),(np.float32,vec_len)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_out(pmt.intern('detected_signals'))         
              self.sample_rate = sample_rate
              self.fft_size = vec_len
              self.rx_freq_mhz = rx_freq_mhz

          def work(self, input_items,output_items):
              for vecindx in range(len(input_items[0])):
                  if len(np.nonzero(input_items[0][vecindx] > input_items[1][vecindx][0])[0])>0:
                      max_index = (input_items[0][vecindx]).argmax()
                      max_freq = str(round((max_index/int(self.fft_size))*float(self.sample_rate)/1e6 - (float(self.sample_rate)/2e6) + float(self.rx_freq_mhz),4)*1000000)
                      max_power = str(int(input_items[0][vecindx][np.nonzero(input_items[0][vecindx] > input_items[1][0])].max()))
                      self.message_port_pub(pmt.intern('detected_signals'), pmt.intern('TSI:/Signal Found/' + max_freq + '/' + max_power + '/' + str(time.time())))

              return len(input_items[0])
    rx_freq_mhz: rx_freq
    sample_rate: samp_rate
    vec_len: fft_size
  states: {}
- name: gain_default
  id: parameter
  parameters:
    label: gain_default
    type: str
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: ip_address
  id: parameter
  parameters:
    label: ip_address
    type: str
    value: ''
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: fft_size
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '4'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: rx_freq_default
  id: parameter
  parameters:
    label: rx_freq_default
    type: str
    value: '102.4'
  states: {}
- name: sample_rate_default
  id: parameter
  parameters:
    label: sample_rate_default
    type: str
    value: 2e6
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    center_freq: float(rx_freq)*1e6
    center_freq0: '0'
    center_freq1: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: 59-float(rx_gain)
    if_gRdB0: '40'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gRLNA0: '0'
    rf_gRLNA1: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_gRdB0: '0'
    rf_gRdB1: '0'
    rf_notch_filter: 'False'
    rsp_selector: str(serial)
    rspduo_mode: Single Tuner
    sample_rate: float(samp_rate)
    sample_rate_non_single_tuner: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    synchronous_updates: 'False'
  states: {}
- name: sensor_node_ip_address
  id: parameter
  parameters:
    label: sensor_node_ip_address
    type: str
    value: '"127.0.0.1"'
  states: {state: disabled}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: ''
  states: {}
- name: threshold_default
  id: parameter
  parameters:
    label: threshold_default
    type: str
    value: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_max_xx_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_add_xx_0, '0', logpwrfft_x_0, '0']
- [blocks_max_xx_0, '0', epy_block_0, '0']
- [blocks_max_xx_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_max_xx_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_0, '1']
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '3']
- [blocks_vector_source_x_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_vector_source_x_0_1, '0', qtgui_vector_sink_f_0, '2']
- [epy_block_0, detected_signals, ainfosec_msg_str_to_PUB_1, Message]
- [logpwrfft_x_0, '0', blocks_add_const_vxx_0, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [sdrplay3_rspduo_0, '0', logpwrfft_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
